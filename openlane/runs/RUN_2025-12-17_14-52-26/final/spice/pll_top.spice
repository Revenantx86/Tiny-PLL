* NGSPICE file created from pll_top.ext - technology: sky130A

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_3 abstract view
.subckt sky130_fd_sc_hd__decap_3 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_ef_sc_hd__decap_12 abstract view
.subckt sky130_ef_sc_hd__decap_12 VPWR VGND VPB VNB
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor2_1 abstract view
.subckt sky130_fd_sc_hd__nor2_1 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfxtp_1 abstract view
.subckt sky130_fd_sc_hd__dfxtp_1 CLK D VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__tapvpwrvgnd_1 abstract view
.subckt sky130_fd_sc_hd__tapvpwrvgnd_1 VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_8 abstract view
.subckt sky130_fd_sc_hd__decap_8 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__fill_1 abstract view
.subckt sky130_fd_sc_hd__fill_1 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_4 abstract view
.subckt sky130_fd_sc_hd__decap_4 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand2_1 abstract view
.subckt sky130_fd_sc_hd__nand2_1 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__fill_2 abstract view
.subckt sky130_fd_sc_hd__fill_2 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a211o_1 abstract view
.subckt sky130_fd_sc_hd__a211o_1 A1 A2 B1 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_1 abstract view
.subckt sky130_fd_sc_hd__buf_1 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or2_1 abstract view
.subckt sky130_fd_sc_hd__or2_1 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21oi_1 abstract view
.subckt sky130_fd_sc_hd__a21oi_1 A1 A2 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_6 abstract view
.subckt sky130_fd_sc_hd__buf_6 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_6 abstract view
.subckt sky130_fd_sc_hd__decap_6 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o221a_1 abstract view
.subckt sky130_fd_sc_hd__o221a_1 A1 A2 B1 B2 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or4b_1 abstract view
.subckt sky130_fd_sc_hd__or4b_1 A B C D_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and2_1 abstract view
.subckt sky130_fd_sc_hd__and2_1 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand3_1 abstract view
.subckt sky130_fd_sc_hd__nand3_1 A B C VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__xor2_1 abstract view
.subckt sky130_fd_sc_hd__xor2_1 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and3_1 abstract view
.subckt sky130_fd_sc_hd__and3_1 A B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and4_1 abstract view
.subckt sky130_fd_sc_hd__and4_1 A B C D VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlygate4sd3_1 abstract view
.subckt sky130_fd_sc_hd__dlygate4sd3_1 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21a_1 abstract view
.subckt sky130_fd_sc_hd__o21a_1 A1 A2 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21o_1 abstract view
.subckt sky130_fd_sc_hd__a21o_1 A1 A2 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_2 abstract view
.subckt sky130_fd_sc_hd__buf_2 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o32a_1 abstract view
.subckt sky130_fd_sc_hd__o32a_1 A1 A2 A3 B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and4b_1 abstract view
.subckt sky130_fd_sc_hd__and4b_1 A_N B C D VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a31o_1 abstract view
.subckt sky130_fd_sc_hd__a31o_1 A1 A2 A3 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlymetal6s2s_1 abstract view
.subckt sky130_fd_sc_hd__dlymetal6s2s_1 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_2 abstract view
.subckt sky130_fd_sc_hd__clkbuf_2 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or3_1 abstract view
.subckt sky130_fd_sc_hd__or3_1 A B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o22ai_1 abstract view
.subckt sky130_fd_sc_hd__o22ai_1 A1 A2 B1 B2 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_8 abstract view
.subckt sky130_fd_sc_hd__clkbuf_8 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and3b_1 abstract view
.subckt sky130_fd_sc_hd__and3b_1 A_N B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21ai_1 abstract view
.subckt sky130_fd_sc_hd__o21ai_1 A1 A2 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a221o_1 abstract view
.subckt sky130_fd_sc_hd__a221o_1 A1 A2 B1 B2 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__xnor2_2 abstract view
.subckt sky130_fd_sc_hd__xnor2_2 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a22oi_1 abstract view
.subckt sky130_fd_sc_hd__a22oi_1 A1 A2 B1 B2 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor3b_2 abstract view
.subckt sky130_fd_sc_hd__nor3b_2 A B C_N VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_1 abstract view
.subckt sky130_fd_sc_hd__clkbuf_1 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o311a_4 abstract view
.subckt sky130_fd_sc_hd__o311a_4 A1 A2 A3 B1 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21bo_1 abstract view
.subckt sky130_fd_sc_hd__a21bo_1 A1 A2 B1_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__mux2_2 abstract view
.subckt sky130_fd_sc_hd__mux2_2 A0 A1 S VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a2bb2o_1 abstract view
.subckt sky130_fd_sc_hd__a2bb2o_1 A1_N A2_N B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a22o_1 abstract view
.subckt sky130_fd_sc_hd__a22o_1 A1 A2 B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o22a_1 abstract view
.subckt sky130_fd_sc_hd__o22a_1 A1 A2 B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and2b_1 abstract view
.subckt sky130_fd_sc_hd__and2b_1 A_N B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__xnor2_1 abstract view
.subckt sky130_fd_sc_hd__xnor2_1 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__xor2_2 abstract view
.subckt sky130_fd_sc_hd__xor2_2 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__inv_2 abstract view
.subckt sky130_fd_sc_hd__inv_2 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__bufinv_16 abstract view
.subckt sky130_fd_sc_hd__bufinv_16 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o211ai_2 abstract view
.subckt sky130_fd_sc_hd__o211ai_2 A1 A2 B1 C1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o41a_1 abstract view
.subckt sky130_fd_sc_hd__o41a_1 A1 A2 A3 A4 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand2b_1 abstract view
.subckt sky130_fd_sc_hd__nand2b_1 A_N B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a221oi_2 abstract view
.subckt sky130_fd_sc_hd__a221oi_2 A1 A2 B1 B2 C1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21ba_1 abstract view
.subckt sky130_fd_sc_hd__o21ba_1 A1 A2 B1_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkinvlp_4 abstract view
.subckt sky130_fd_sc_hd__clkinvlp_4 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a31oi_1 abstract view
.subckt sky130_fd_sc_hd__a31oi_1 A1 A2 A3 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor3b_1 abstract view
.subckt sky130_fd_sc_hd__nor3b_1 A B C_N VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__inv_6 abstract view
.subckt sky130_fd_sc_hd__inv_6 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfxtp_2 abstract view
.subckt sky130_fd_sc_hd__dfxtp_2 CLK D VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21boi_1 abstract view
.subckt sky130_fd_sc_hd__a21boi_1 A1 A2 B1_N VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a2111o_1 abstract view
.subckt sky130_fd_sc_hd__a2111o_1 A1 A2 B1 C1 D1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a311o_1 abstract view
.subckt sky130_fd_sc_hd__a311o_1 A1 A2 A3 B1 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or4_2 abstract view
.subckt sky130_fd_sc_hd__or4_2 A B C D VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21boi_4 abstract view
.subckt sky130_fd_sc_hd__a21boi_4 A1 A2 B1_N VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o211a_1 abstract view
.subckt sky130_fd_sc_hd__o211a_1 A1 A2 B1 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or3b_1 abstract view
.subckt sky130_fd_sc_hd__or3b_1 A B C_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o311a_1 abstract view
.subckt sky130_fd_sc_hd__o311a_1 A1 A2 A3 B1 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or4_1 abstract view
.subckt sky130_fd_sc_hd__or4_1 A B C D VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o211ai_1 abstract view
.subckt sky130_fd_sc_hd__o211ai_1 A1 A2 B1 C1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand3b_1 abstract view
.subckt sky130_fd_sc_hd__nand3b_1 A_N B C VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__mux2_1 abstract view
.subckt sky130_fd_sc_hd__mux2_1 A0 A1 S VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfrtp_1 abstract view
.subckt sky130_fd_sc_hd__dfrtp_1 CLK D RESET_B VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkinv_4 abstract view
.subckt sky130_fd_sc_hd__clkinv_4 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o31ai_1 abstract view
.subckt sky130_fd_sc_hd__o31ai_1 A1 A2 A3 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor4_1 abstract view
.subckt sky130_fd_sc_hd__nor4_1 A B C D VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o31a_1 abstract view
.subckt sky130_fd_sc_hd__o31a_1 A1 A2 A3 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a32o_1 abstract view
.subckt sky130_fd_sc_hd__a32o_1 A1 A2 A3 B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor3_1 abstract view
.subckt sky130_fd_sc_hd__nor3_1 A B C VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21oi_4 abstract view
.subckt sky130_fd_sc_hd__a21oi_4 A1 A2 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a211oi_2 abstract view
.subckt sky130_fd_sc_hd__a211oi_2 A1 A2 B1 C1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a22oi_2 abstract view
.subckt sky130_fd_sc_hd__a22oi_2 A1 A2 B1 B2 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21bai_1 abstract view
.subckt sky130_fd_sc_hd__o21bai_1 A1 A2 B1_N VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__xnor2_4 abstract view
.subckt sky130_fd_sc_hd__xnor2_4 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or3_2 abstract view
.subckt sky130_fd_sc_hd__or3_2 A B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o2bb2a_1 abstract view
.subckt sky130_fd_sc_hd__o2bb2a_1 A1_N A2_N B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or4_4 abstract view
.subckt sky130_fd_sc_hd__or4_4 A B C D VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_4 abstract view
.subckt sky130_fd_sc_hd__buf_4 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21oi_2 abstract view
.subckt sky130_fd_sc_hd__a21oi_2 A1 A2 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a221oi_4 abstract view
.subckt sky130_fd_sc_hd__a221oi_4 A1 A2 B1 B2 C1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and4bb_1 abstract view
.subckt sky130_fd_sc_hd__and4bb_1 A_N B_N C D VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a2111oi_1 abstract view
.subckt sky130_fd_sc_hd__a2111oi_1 A1 A2 B1 C1 D1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a211oi_1 abstract view
.subckt sky130_fd_sc_hd__a211oi_1 A1 A2 B1 C1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor2_4 abstract view
.subckt sky130_fd_sc_hd__nor2_4 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or3b_4 abstract view
.subckt sky130_fd_sc_hd__or3b_4 A B C_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o221ai_1 abstract view
.subckt sky130_fd_sc_hd__o221ai_1 A1 A2 B1 B2 C1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or4b_4 abstract view
.subckt sky130_fd_sc_hd__or4b_4 A B C D_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlygate4sd1_1 abstract view
.subckt sky130_fd_sc_hd__dlygate4sd1_1 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_16 abstract view
.subckt sky130_fd_sc_hd__clkbuf_16 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a31oi_2 abstract view
.subckt sky130_fd_sc_hd__a31oi_2 A1 A2 A3 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o2111ai_4 abstract view
.subckt sky130_fd_sc_hd__o2111ai_4 A1 A2 B1 C1 D1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21boi_2 abstract view
.subckt sky130_fd_sc_hd__a21boi_2 A1 A2 B1_N VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or3_4 abstract view
.subckt sky130_fd_sc_hd__or3_4 A B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or4bb_4 abstract view
.subckt sky130_fd_sc_hd__or4bb_4 A B C_N D_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_8 abstract view
.subckt sky130_fd_sc_hd__buf_8 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand4b_1 abstract view
.subckt sky130_fd_sc_hd__nand4b_1 A_N B C D VGND VNB VPB VPWR Y
.ends

.subckt pll_top VGND VPWR debug_dco_word[0] debug_dco_word[10] debug_dco_word[11]
+ debug_dco_word[12] debug_dco_word[13] debug_dco_word[14] debug_dco_word[15] debug_dco_word[16]
+ debug_dco_word[17] debug_dco_word[18] debug_dco_word[19] debug_dco_word[1] debug_dco_word[20]
+ debug_dco_word[21] debug_dco_word[22] debug_dco_word[23] debug_dco_word[24] debug_dco_word[25]
+ debug_dco_word[26] debug_dco_word[27] debug_dco_word[28] debug_dco_word[29] debug_dco_word[2]
+ debug_dco_word[30] debug_dco_word[31] debug_dco_word[3] debug_dco_word[4] debug_dco_word[5]
+ debug_dco_word[6] debug_dco_word[7] debug_dco_word[8] debug_dco_word[9] div_val[0]
+ div_val[10] div_val[11] div_val[12] div_val[13] div_val[14] div_val[15] div_val[16]
+ div_val[17] div_val[18] div_val[19] div_val[1] div_val[20] div_val[21] div_val[22]
+ div_val[23] div_val[24] div_val[25] div_val[26] div_val[27] div_val[28] div_val[29]
+ div_val[2] div_val[30] div_val[31] div_val[3] div_val[4] div_val[5] div_val[6] div_val[7]
+ div_val[8] div_val[9] initial_freq[0] initial_freq[10] initial_freq[11] initial_freq[12]
+ initial_freq[13] initial_freq[14] initial_freq[15] initial_freq[16] initial_freq[17]
+ initial_freq[18] initial_freq[19] initial_freq[1] initial_freq[20] initial_freq[21]
+ initial_freq[22] initial_freq[23] initial_freq[24] initial_freq[25] initial_freq[26]
+ initial_freq[27] initial_freq[28] initial_freq[29] initial_freq[2] initial_freq[30]
+ initial_freq[31] initial_freq[3] initial_freq[4] initial_freq[5] initial_freq[6]
+ initial_freq[7] initial_freq[8] initial_freq[9] lock_detect pll_out ref_clk rst_n
+ sys_clk
XFILLER_54_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_54_203 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2037_ _0897_ net103 VGND VGND VPWR VPWR _0123_ sky130_fd_sc_hd__nor2_1
X_2106_ clknet_4_4_0_sys_clk _0044_ VGND VGND VPWR VPWR lf_inst.integrator\[8\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_60_492 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_22_111 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_22_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_45_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_26_96 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_26_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_26_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_13_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_5_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_8_181 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1270_ net257 _0654_ VGND VGND VPWR VPWR _0655_ sky130_fd_sc_hd__nand2_1
XFILLER_36_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1606_ net309 net149 _0976_ _0977_ VGND VGND VPWR VPWR _0047_ sky130_fd_sc_hd__a211o_1
X_1468_ _0831_ _0850_ VGND VGND VPWR VPWR _0851_ sky130_fd_sc_hd__nand2_1
XFILLER_47_18 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout105 net111 VGND VGND VPWR VPWR net105 sky130_fd_sc_hd__buf_1
Xfanout127 net130 VGND VGND VPWR VPWR net127 sky130_fd_sc_hd__buf_1
Xfanout149 net150 VGND VGND VPWR VPWR net149 sky130_fd_sc_hd__buf_1
X_1399_ net121 _0781_ VGND VGND VPWR VPWR _0782_ sky130_fd_sc_hd__or2_1
X_1537_ net120 _0809_ div_inst.counter\[5\] VGND VGND VPWR VPWR _0920_ sky130_fd_sc_hd__a21oi_1
Xfanout138 net140 VGND VGND VPWR VPWR net138 sky130_fd_sc_hd__buf_6
XFILLER_27_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_27_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_37_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_5_162 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_53_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_37_95 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_28_297 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_5_140 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_11_197 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1253_ _0623_ _0631_ _0639_ _0628_ _0633_ VGND VGND VPWR VPWR _0640_ sky130_fd_sc_hd__o221a_1
XFILLER_56_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1322_ _0698_ _0699_ _0701_ _0704_ VGND VGND VPWR VPWR _0705_ sky130_fd_sc_hd__or4b_1
X_1184_ dco_inst.accumulator\[20\] net79 VGND VGND VPWR VPWR _0579_ sky130_fd_sc_hd__nand2_1
XFILLER_24_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_17_291 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_19_242 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_32_283 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_59_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_58_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_2_143 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_25_278 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_15_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_15_239 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_23_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_38_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_2_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1940_ _0155_ _0156_ net132 VGND VGND VPWR VPWR _0375_ sky130_fd_sc_hd__a21oi_1
XFILLER_9_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1871_ _0963_ net134 VGND VGND VPWR VPWR _0316_ sky130_fd_sc_hd__and2_1
XFILLER_50_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1236_ _0608_ _0617_ _0618_ VGND VGND VPWR VPWR _0625_ sky130_fd_sc_hd__nand3_1
XFILLER_49_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1305_ net25 _0678_ VGND VGND VPWR VPWR _0688_ sky130_fd_sc_hd__xor2_1
X_1167_ _0562_ _0563_ _0564_ VGND VGND VPWR VPWR _0021_ sky130_fd_sc_hd__a21oi_1
X_1098_ dco_inst.accumulator\[8\] net97 VGND VGND VPWR VPWR _0505_ sky130_fd_sc_hd__nand2_1
XFILLER_60_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_20_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_8_Left_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_43_323 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_18_64 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_34_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_50_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_7_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_38_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2070_ clknet_4_4_0_sys_clk _0011_ VGND VGND VPWR VPWR dco_inst.accumulator\[7\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_15_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_44_395 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1923_ _1022_ _1021_ _0358_ VGND VGND VPWR VPWR _0360_ sky130_fd_sc_hd__and3_1
X_1785_ _0246_ _0247_ VGND VGND VPWR VPWR _0073_ sky130_fd_sc_hd__nor2_1
X_1854_ net295 net148 _0301_ _0959_ VGND VGND VPWR VPWR _0088_ sky130_fd_sc_hd__a211o_1
X_1219_ _0593_ _0594_ _0601_ _0602_ VGND VGND VPWR VPWR _0610_ sky130_fd_sc_hd__and4_1
X_2199_ net216 _0130_ VGND VGND VPWR VPWR div_inst.counter\[16\] sky130_fd_sc_hd__dfxtp_1
XFILLER_52_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_52_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_35_340 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold41 net77 VGND VGND VPWR VPWR net316 sky130_fd_sc_hd__dlygate4sd3_1
Xhold63 lf_inst.zero_error_count\[0\] VGND VGND VPWR VPWR net338 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_29_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xhold30 lf_inst.integrator\[1\] VGND VGND VPWR VPWR net305 sky130_fd_sc_hd__dlygate4sd3_1
Xhold52 unlock_timer\[1\] VGND VGND VPWR VPWR net327 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_58_476 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_41_376 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1570_ net270 _0897_ _0898_ net264 _0952_ VGND VGND VPWR VPWR _0953_ sky130_fd_sc_hd__o221a_1
XFILLER_3_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2053_ _0851_ net108 VGND VGND VPWR VPWR _0139_ sky130_fd_sc_hd__nor2_1
X_2122_ clknet_4_15_0_sys_clk _0060_ VGND VGND VPWR VPWR lf_inst.integrator\[23\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_13_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_19_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_34_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_32_321 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_22_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1768_ _0229_ _0232_ _0230_ VGND VGND VPWR VPWR _0235_ sky130_fd_sc_hd__o21a_1
X_1837_ lf_inst.integrator\[4\] net136 VGND VGND VPWR VPWR _0287_ sky130_fd_sc_hd__nand2_1
X_1906_ net72 net152 _1003_ VGND VGND VPWR VPWR _0346_ sky130_fd_sc_hd__a21o_1
XFILLER_57_212 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1699_ _0173_ _0174_ VGND VGND VPWR VPWR _0175_ sky130_fd_sc_hd__nor2_1
XFILLER_40_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_15_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_31_86 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_31_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xoutput75 net75 VGND VGND VPWR VPWR debug_dco_word[17] sky130_fd_sc_hd__buf_2
XFILLER_0_230 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xoutput86 net86 VGND VGND VPWR VPWR debug_dco_word[27] sky130_fd_sc_hd__buf_2
XFILLER_56_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_56_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xoutput97 net97 VGND VGND VPWR VPWR debug_dco_word[8] sky130_fd_sc_hd__buf_2
XFILLER_31_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_16_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_16_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_16_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1622_ _0979_ net280 _0985_ net142 _0457_ VGND VGND VPWR VPWR _0991_ sky130_fd_sc_hd__o32a_1
X_1484_ div_inst.counter\[18\] net114 div_inst.counter\[19\] VGND VGND VPWR VPWR _0867_
+ sky130_fd_sc_hd__a21oi_1
X_1553_ _0869_ _0871_ _0878_ _0935_ VGND VGND VPWR VPWR _0936_ sky130_fd_sc_hd__and4b_1
XFILLER_54_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2105_ clknet_4_1_0_sys_clk _0043_ VGND VGND VPWR VPWR lf_inst.integrator\[7\] sky130_fd_sc_hd__dfxtp_1
X_2036_ _0899_ net103 VGND VGND VPWR VPWR _0122_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_60_493 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_22_123 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_22_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_53_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_45_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_37_Left_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_13_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_42_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_39_Left_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_3_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1605_ net227 net34 VGND VGND VPWR VPWR _0977_ sky130_fd_sc_hd__and2_1
X_1536_ _0811_ _0918_ VGND VGND VPWR VPWR _0919_ sky130_fd_sc_hd__nand2_1
X_1467_ div_inst.counter\[24\] _0827_ _0828_ div_inst.counter\[25\] VGND VGND VPWR
+ VPWR _0850_ sky130_fd_sc_hd__a31o_1
Xfanout117 div_inst.counter\[22\] VGND VGND VPWR VPWR net117 sky130_fd_sc_hd__dlymetal6s2s_1
Xfanout128 net130 VGND VGND VPWR VPWR net128 sky130_fd_sc_hd__buf_1
Xfanout106 net110 VGND VGND VPWR VPWR net106 sky130_fd_sc_hd__clkbuf_2
X_1398_ net23 _0659_ VGND VGND VPWR VPWR _0781_ sky130_fd_sc_hd__xor2_1
Xfanout139 net191 VGND VGND VPWR VPWR net139 sky130_fd_sc_hd__clkbuf_2
X_2019_ _0441_ _0442_ VGND VGND VPWR VPWR _0443_ sky130_fd_sc_hd__nand2_1
XFILLER_35_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_33_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_5_163 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_41_295 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_28_298 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_5_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_11_198 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1252_ _0624_ _0631_ _0632_ VGND VGND VPWR VPWR _0639_ sky130_fd_sc_hd__or3_1
X_1321_ div_inst.counter\[25\] _0700_ _0703_ div_inst.counter\[24\] VGND VGND VPWR
+ VPWR _0704_ sky130_fd_sc_hd__o22ai_1
XFILLER_49_351 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1183_ dco_inst.accumulator\[20\] net79 VGND VGND VPWR VPWR _0578_ sky130_fd_sc_hd__or2_1
XTAP_TAPCELL_ROW_19_243 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_32_295 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_59_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_58_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_4_10_0_sys_clk clknet_0_sys_clk VGND VGND VPWR VPWR clknet_4_10_0_sys_clk
+ sky130_fd_sc_hd__clkbuf_8
X_1519_ div_inst.counter\[3\] _0808_ VGND VGND VPWR VPWR _0902_ sky130_fd_sc_hd__nor2_1
XPHY_EDGE_ROW_12_Right_12 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_2_144 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_21_Right_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_25_279 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_23_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_30_Right_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_46_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_16_224 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1870_ _0963_ net134 VGND VGND VPWR VPWR _0315_ sky130_fd_sc_hd__nor2_1
XFILLER_43_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_24_Left_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1235_ _0622_ _0623_ VGND VGND VPWR VPWR _0624_ sky130_fd_sc_hd__nand2_1
X_1304_ _0685_ _0686_ _0681_ VGND VGND VPWR VPWR _0687_ sky130_fd_sc_hd__and3b_1
X_1166_ _0562_ _0563_ net248 VGND VGND VPWR VPWR _0564_ sky130_fd_sc_hd__o21ai_1
X_1097_ dco_inst.accumulator\[8\] net97 VGND VGND VPWR VPWR _0504_ sky130_fd_sc_hd__or2_1
X_1999_ _0415_ _0418_ VGND VGND VPWR VPWR _0425_ sky130_fd_sc_hd__or2_1
XFILLER_43_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_38_360 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_18_32 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_18_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_50_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_7_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_50_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_50_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_44_396 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_34_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1922_ _1021_ _1022_ _0358_ VGND VGND VPWR VPWR _0359_ sky130_fd_sc_hd__a21oi_1
X_1784_ net297 _0245_ net141 VGND VGND VPWR VPWR _0247_ sky130_fd_sc_hd__o21ai_1
X_1853_ _0299_ _0300_ VGND VGND VPWR VPWR _0301_ sky130_fd_sc_hd__nor2_1
X_1218_ dco_inst.accumulator\[22\] net81 _0601_ VGND VGND VPWR VPWR _0609_ sky130_fd_sc_hd__and3_1
XFILLER_37_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2198_ net216 _0129_ VGND VGND VPWR VPWR div_inst.counter\[15\] sky130_fd_sc_hd__dfxtp_1
X_1149_ dco_inst.accumulator\[15\] net73 VGND VGND VPWR VPWR _0549_ sky130_fd_sc_hd__and2_1
XFILLER_40_316 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_35_341 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_20_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold64 _0079_ VGND VGND VPWR VPWR net339 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_29_64 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xhold42 net75 VGND VGND VPWR VPWR net317 sky130_fd_sc_hd__dlygate4sd3_1
Xhold53 lf_inst.integrator\[6\] VGND VGND VPWR VPWR net328 sky130_fd_sc_hd__dlygate4sd3_1
Xhold31 net96 VGND VGND VPWR VPWR net306 sky130_fd_sc_hd__dlygate4sd3_1
Xhold20 net95 VGND VGND VPWR VPWR net295 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_58_477 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_45_63 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_31_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_16_324 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_41_377 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2052_ _0853_ net108 VGND VGND VPWR VPWR _0138_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_49_422 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2121_ clknet_4_15_0_sys_clk _0059_ VGND VGND VPWR VPWR lf_inst.integrator\[22\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_19_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_32_322 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1905_ _0341_ _0343_ VGND VGND VPWR VPWR _0345_ sky130_fd_sc_hd__nand2_1
X_1698_ net198 lf_inst.integrator\[22\] VGND VGND VPWR VPWR _0174_ sky130_fd_sc_hd__and2_1
X_1767_ net290 net156 _0233_ net175 _0234_ VGND VGND VPWR VPWR _0067_ sky130_fd_sc_hd__a221o_1
X_1836_ lf_inst.integrator\[4\] net136 VGND VGND VPWR VPWR _0286_ sky130_fd_sc_hd__or2_1
XPHY_EDGE_ROW_6_Right_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_57_202 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_55_458 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_11_Left_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xoutput87 net87 VGND VGND VPWR VPWR debug_dco_word[28] sky130_fd_sc_hd__buf_2
Xoutput76 net76 VGND VGND VPWR VPWR debug_dco_word[18] sky130_fd_sc_hd__buf_2
Xoutput98 net98 VGND VGND VPWR VPWR debug_dco_word[9] sky130_fd_sc_hd__buf_2
XFILLER_0_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_16_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_59_Right_59 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_31_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_16_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1552_ net9 _0874_ _0885_ net8 _0875_ VGND VGND VPWR VPWR _0935_ sky130_fd_sc_hd__o221a_1
XFILLER_8_342 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1621_ lf_inst.integrator\[13\] _0989_ VGND VGND VPWR VPWR _0990_ sky130_fd_sc_hd__xnor2_2
X_1483_ net276 _0863_ _0865_ net14 VGND VGND VPWR VPWR _0866_ sky130_fd_sc_hd__a22oi_1
XFILLER_39_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2104_ clknet_4_1_0_sys_clk _0042_ VGND VGND VPWR VPWR lf_inst.integrator\[6\] sky130_fd_sc_hd__dfxtp_1
X_2035_ _0916_ net101 VGND VGND VPWR VPWR _0121_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_60_494 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_22_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1819_ net223 net207 net185 VGND VGND VPWR VPWR _0271_ sky130_fd_sc_hd__nor3b_2
XFILLER_26_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_53_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_13_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_3_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout129 net130 VGND VGND VPWR VPWR net129 sky130_fd_sc_hd__clkbuf_1
Xfanout107 net110 VGND VGND VPWR VPWR net107 sky130_fd_sc_hd__buf_1
Xfanout118 div_inst.counter\[13\] VGND VGND VPWR VPWR net118 sky130_fd_sc_hd__buf_1
X_1604_ net166 _0975_ VGND VGND VPWR VPWR _0976_ sky130_fd_sc_hd__nor2_1
X_1535_ div_inst.counter\[6\] _0810_ VGND VGND VPWR VPWR _0918_ sky130_fd_sc_hd__or2_1
X_1466_ net269 _0847_ VGND VGND VPWR VPWR _0849_ sky130_fd_sc_hd__nor2_1
X_1397_ div_inst.counter\[3\] _0778_ VGND VGND VPWR VPWR _0780_ sky130_fd_sc_hd__or2_1
X_2018_ _0430_ _0427_ _0436_ _0435_ _0428_ VGND VGND VPWR VPWR _0442_ sky130_fd_sc_hd__o311a_4
XFILLER_42_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_35_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_35_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_10_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_6_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_10_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_28_299 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1320_ net112 _0702_ VGND VGND VPWR VPWR _0703_ sky130_fd_sc_hd__and2_1
XFILLER_5_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_11_199 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1251_ _0636_ _0637_ VGND VGND VPWR VPWR _0638_ sky130_fd_sc_hd__nand2_1
X_1182_ _0576_ _0577_ VGND VGND VPWR VPWR _0023_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_19_244 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_58_Left_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1449_ div_inst.counter\[27\] div_inst.counter\[26\] VGND VGND VPWR VPWR _0832_ sky130_fd_sc_hd__and2_1
Xclkbuf_4_14_0_sys_clk clknet_0_sys_clk VGND VGND VPWR VPWR clknet_4_14_0_sys_clk
+ sky130_fd_sc_hd__clkbuf_8
X_1518_ net32 _0899_ VGND VGND VPWR VPWR _0901_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_2_145 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_15_208 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_3_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_48_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_48_52 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_16_225 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_9_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1303_ div_inst.counter\[29\] _0683_ VGND VGND VPWR VPWR _0686_ sky130_fd_sc_hd__nand2_1
X_1234_ dco_inst.accumulator\[26\] net85 VGND VGND VPWR VPWR _0623_ sky130_fd_sc_hd__nand2_1
X_1165_ _0554_ _0558_ _0553_ VGND VGND VPWR VPWR _0563_ sky130_fd_sc_hd__a21bo_1
X_1096_ _0502_ _0503_ VGND VGND VPWR VPWR _0011_ sky130_fd_sc_hd__and2_1
X_1998_ net169 _0423_ _0424_ VGND VGND VPWR VPWR _0109_ sky130_fd_sc_hd__o21ai_1
XTAP_TAPCELL_ROW_38_361 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_13_206 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_59_95 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_46_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_46_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_44_397 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_34_336 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1921_ net208 net142 _0989_ VGND VGND VPWR VPWR _0358_ sky130_fd_sc_hd__a21bo_1
X_1852_ _0296_ _0297_ _0298_ net166 VGND VGND VPWR VPWR _0300_ sky130_fd_sc_hd__a31o_1
X_1783_ unlock_timer\[3\] _0245_ VGND VGND VPWR VPWR _0246_ sky130_fd_sc_hd__and2_1
X_1217_ _0606_ _0607_ VGND VGND VPWR VPWR _0608_ sky130_fd_sc_hd__and2_1
XFILLER_52_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_35_342 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2197_ net214 _0128_ VGND VGND VPWR VPWR div_inst.counter\[14\] sky130_fd_sc_hd__dfxtp_1
XFILLER_25_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1079_ _0487_ _0488_ VGND VGND VPWR VPWR _0489_ sky130_fd_sc_hd__and2_1
X_1148_ dco_inst.accumulator\[15\] net73 VGND VGND VPWR VPWR _0548_ sky130_fd_sc_hd__nor2_1
XFILLER_40_328 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_58_478 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold43 net86 VGND VGND VPWR VPWR net318 sky130_fd_sc_hd__dlygate4sd3_1
Xhold32 net88 VGND VGND VPWR VPWR net307 sky130_fd_sc_hd__dlygate4sd3_1
Xhold65 lf_inst.integrator\[21\] VGND VGND VPWR VPWR net340 sky130_fd_sc_hd__dlygate4sd3_1
Xhold54 lf_inst.integrator\[20\] VGND VGND VPWR VPWR net329 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_29_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_29_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_28_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold21 lf_inst.integrator\[9\] VGND VGND VPWR VPWR net296 sky130_fd_sc_hd__dlygate4sd3_1
Xhold10 unlock_timer\[4\] VGND VGND VPWR VPWR net285 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_45_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_45_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_43_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_43_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_41_378 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_49_423 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2120_ clknet_4_15_0_sys_clk _0058_ VGND VGND VPWR VPWR lf_inst.integrator\[21\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_20_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2051_ _0859_ net108 VGND VGND VPWR VPWR _0137_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_32_323 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1835_ net322 net148 _0285_ net174 _0957_ VGND VGND VPWR VPWR _0085_ sky130_fd_sc_hd__a221o_1
X_1904_ _0341_ _0343_ VGND VGND VPWR VPWR _0344_ sky130_fd_sc_hd__or2_1
X_1766_ net233 net56 VGND VGND VPWR VPWR _0234_ sky130_fd_sc_hd__and2_1
X_1697_ net199 lf_inst.integrator\[22\] VGND VGND VPWR VPWR _0173_ sky130_fd_sc_hd__nor2_1
XFILLER_57_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_57_236 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_55_459 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_40_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xoutput88 net88 VGND VGND VPWR VPWR debug_dco_word[29] sky130_fd_sc_hd__buf_2
Xoutput77 net77 VGND VGND VPWR VPWR debug_dco_word[19] sky130_fd_sc_hd__buf_2
XFILLER_0_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xoutput99 net99 VGND VGND VPWR VPWR lock_detect sky130_fd_sc_hd__buf_2
XFILLER_56_63 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_46_404 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_16_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_31_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_31_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_8_354 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_16_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1482_ _0826_ _0864_ VGND VGND VPWR VPWR _0865_ sky130_fd_sc_hd__or2_1
X_1551_ _0887_ _0933_ VGND VGND VPWR VPWR _0934_ sky130_fd_sc_hd__or2_1
X_1620_ net188 net203 net224 VGND VGND VPWR VPWR _0989_ sky130_fd_sc_hd__mux2_2
X_2103_ clknet_4_0_0_sys_clk _0041_ VGND VGND VPWR VPWR lf_inst.integrator\[5\] sky130_fd_sc_hd__dfxtp_1
X_2034_ _0919_ net102 VGND VGND VPWR VPWR _0120_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_60_495 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_10_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1818_ _0269_ _0270_ net78 net150 VGND VGND VPWR VPWR _0083_ sky130_fd_sc_hd__a2bb2o_1
X_1749_ _0216_ _0218_ VGND VGND VPWR VPWR _0219_ sky130_fd_sc_hd__nand2_1
XFILLER_9_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_5_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_3_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1465_ net268 _0846_ _0847_ net269 VGND VGND VPWR VPWR _0848_ sky130_fd_sc_hd__a22o_1
Xfanout108 net109 VGND VGND VPWR VPWR net108 sky130_fd_sc_hd__dlymetal6s2s_1
Xfanout119 div_inst.counter\[13\] VGND VGND VPWR VPWR net119 sky130_fd_sc_hd__clkbuf_1
X_1603_ _0962_ _0974_ VGND VGND VPWR VPWR _0975_ sky130_fd_sc_hd__xnor2_2
X_1534_ net31 _0916_ VGND VGND VPWR VPWR _0917_ sky130_fd_sc_hd__or2_1
X_2017_ _0439_ _0440_ VGND VGND VPWR VPWR _0441_ sky130_fd_sc_hd__or2_1
XFILLER_27_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1396_ div_inst.counter\[3\] _0778_ VGND VGND VPWR VPWR _0779_ sky130_fd_sc_hd__nand2_1
XFILLER_53_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_5_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1250_ dco_inst.accumulator\[28\] net87 VGND VGND VPWR VPWR _0637_ sky130_fd_sc_hd__nand2_1
XFILLER_49_342 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1181_ _0566_ _0571_ _0575_ net237 VGND VGND VPWR VPWR _0577_ sky130_fd_sc_hd__a31o_1
XTAP_TAPCELL_ROW_19_245 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_17_250 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1448_ _0829_ _0830_ VGND VGND VPWR VPWR _0831_ sky130_fd_sc_hd__nand2_1
X_1517_ net270 _0897_ _0899_ net32 VGND VGND VPWR VPWR _0900_ sky130_fd_sc_hd__a22oi_1
X_1379_ _0753_ _0758_ _0759_ _0760_ VGND VGND VPWR VPWR _0762_ sky130_fd_sc_hd__and4_1
XFILLER_23_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_23_67 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_146 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_58_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_48_64 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_48_20 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_9_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_14_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_16_226 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1233_ dco_inst.accumulator\[26\] net85 VGND VGND VPWR VPWR _0622_ sky130_fd_sc_hd__or2_1
X_1302_ div_inst.counter\[29\] _0683_ _0684_ div_inst.counter\[28\] VGND VGND VPWR
+ VPWR _0685_ sky130_fd_sc_hd__o22a_1
XFILLER_49_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_37_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1164_ _0560_ _0561_ VGND VGND VPWR VPWR _0562_ sky130_fd_sc_hd__and2b_1
X_1095_ _0500_ _0501_ net249 VGND VGND VPWR VPWR _0503_ sky130_fd_sc_hd__o21a_1
X_1997_ net318 net159 _0213_ VGND VGND VPWR VPWR _0424_ sky130_fd_sc_hd__a21oi_1
XFILLER_20_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_34_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_34_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_11_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_13_207 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_19_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1920_ net333 net147 _0357_ net168 _1019_ VGND VGND VPWR VPWR _0098_ sky130_fd_sc_hd__o221a_1
X_1851_ _0297_ _0298_ _0296_ VGND VGND VPWR VPWR _0299_ sky130_fd_sc_hd__a21oi_1
X_1782_ _0245_ net141 _0244_ VGND VGND VPWR VPWR _0072_ sky130_fd_sc_hd__and3b_1
X_1216_ dco_inst.accumulator\[24\] net83 VGND VGND VPWR VPWR _0607_ sky130_fd_sc_hd__nand2_1
X_2196_ net214 _0127_ VGND VGND VPWR VPWR div_inst.counter\[13\] sky130_fd_sc_hd__dfxtp_1
XFILLER_40_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_35_343 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_25_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1078_ dco_inst.accumulator\[5\] net94 VGND VGND VPWR VPWR _0488_ sky130_fd_sc_hd__nand2_1
XFILLER_1_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1147_ net248 _0546_ _0547_ VGND VGND VPWR VPWR _0018_ sky130_fd_sc_hd__and3_1
XFILLER_4_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_20_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xhold11 lf_inst.integrator\[19\] VGND VGND VPWR VPWR net286 sky130_fd_sc_hd__dlygate4sd3_1
Xhold22 unlock_timer\[3\] VGND VGND VPWR VPWR net297 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_58_479 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_45_32 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_28_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold66 lf_inst.integrator\[4\] VGND VGND VPWR VPWR net341 sky130_fd_sc_hd__dlygate4sd3_1
Xhold33 net71 VGND VGND VPWR VPWR net308 sky130_fd_sc_hd__dlygate4sd3_1
Xhold44 unlock_timer\[0\] VGND VGND VPWR VPWR net319 sky130_fd_sc_hd__dlygate4sd3_1
Xhold55 lf_inst.integrator\[14\] VGND VGND VPWR VPWR net330 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_41_379 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_6_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2050_ _0861_ net108 VGND VGND VPWR VPWR _0136_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_49_424 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_22_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1765_ _0229_ _0232_ VGND VGND VPWR VPWR _0233_ sky130_fd_sc_hd__xor2_1
XTAP_TAPCELL_ROW_32_324 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1834_ _0282_ _0284_ VGND VGND VPWR VPWR _0285_ sky130_fd_sc_hd__xnor2_1
X_1903_ _0328_ _0332_ _0337_ _0342_ VGND VGND VPWR VPWR _0343_ sky130_fd_sc_hd__a31o_1
X_1696_ net340 net161 _0171_ _0172_ VGND VGND VPWR VPWR _0058_ sky130_fd_sc_hd__a211o_1
X_2179_ clknet_4_11_0_sys_clk _0110_ VGND VGND VPWR VPWR net87 sky130_fd_sc_hd__dfxtp_1
XFILLER_25_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_31_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xoutput67 net67 VGND VGND VPWR VPWR debug_dco_word[0] sky130_fd_sc_hd__buf_2
Xoutput78 net78 VGND VGND VPWR VPWR debug_dco_word[1] sky130_fd_sc_hd__buf_2
Xoutput89 net89 VGND VGND VPWR VPWR debug_dco_word[2] sky130_fd_sc_hd__buf_2
XFILLER_56_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_46_405 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_31_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_8_322 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1481_ div_inst.counter\[20\] _0825_ VGND VGND VPWR VPWR _0864_ sky130_fd_sc_hd__nor2_1
X_1550_ _0892_ _0932_ _0890_ VGND VGND VPWR VPWR _0933_ sky130_fd_sc_hd__o21a_1
XFILLER_47_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2102_ clknet_4_0_0_sys_clk _0040_ VGND VGND VPWR VPWR lf_inst.integrator\[4\] sky130_fd_sc_hd__dfxtp_1
XFILLER_11_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2033_ _0921_ net102 VGND VGND VPWR VPWR _0119_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_60_496 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1748_ _0202_ _0203_ _0210_ _0217_ VGND VGND VPWR VPWR _0218_ sky130_fd_sc_hd__a31o_1
X_1817_ net247 lf_inst.integrator\[1\] _0268_ net150 VGND VGND VPWR VPWR _0270_ sky130_fd_sc_hd__a31o_1
X_1679_ net180 _0155_ _0156_ _0157_ VGND VGND VPWR VPWR _0158_ sky130_fd_sc_hd__a31o_1
XFILLER_3_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_36_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_29_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_44_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_59_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1602_ lf_inst.integrator\[10\] net142 VGND VGND VPWR VPWR _0974_ sky130_fd_sc_hd__xnor2_1
X_1464_ div_inst.counter\[26\] _0831_ VGND VGND VPWR VPWR _0847_ sky130_fd_sc_hd__xor2_2
Xfanout109 net110 VGND VGND VPWR VPWR net109 sky130_fd_sc_hd__clkbuf_2
X_1395_ _0660_ _0777_ VGND VGND VPWR VPWR _0778_ sky130_fd_sc_hd__and2_1
X_1533_ div_inst.counter\[7\] _0811_ VGND VGND VPWR VPWR _0916_ sky130_fd_sc_hd__xor2_1
X_2016_ net193 _0233_ VGND VGND VPWR VPWR _0440_ sky130_fd_sc_hd__nor2_1
XFILLER_50_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_58_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_53_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_26_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_5_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_49_310 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1180_ _0566_ _0571_ _0575_ VGND VGND VPWR VPWR _0576_ sky130_fd_sc_hd__a21oi_1
XFILLER_17_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_19_246 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_27_290 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_10_190 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1516_ div_inst.counter\[8\] _0813_ VGND VGND VPWR VPWR _0899_ sky130_fd_sc_hd__xnor2_1
XFILLER_59_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1447_ div_inst.counter\[25\] div_inst.counter\[24\] VGND VGND VPWR VPWR _0830_ sky130_fd_sc_hd__and2_1
X_1378_ _0760_ VGND VGND VPWR VPWR _0761_ sky130_fd_sc_hd__inv_2
XFILLER_55_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_55_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_23_79 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_48_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_46_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_9_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_14_232 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_16_227 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1232_ _0620_ _0621_ VGND VGND VPWR VPWR _0029_ sky130_fd_sc_hd__nor2_1
X_1301_ net268 _0676_ VGND VGND VPWR VPWR _0684_ sky130_fd_sc_hd__xor2_1
XFILLER_52_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1163_ dco_inst.accumulator\[17\] net75 VGND VGND VPWR VPWR _0561_ sky130_fd_sc_hd__nand2_1
X_1094_ _0500_ _0501_ VGND VGND VPWR VPWR _0502_ sky130_fd_sc_hd__nand2_1
X_1996_ _0421_ _0422_ VGND VGND VPWR VPWR _0423_ sky130_fd_sc_hd__xnor2_1
XFILLER_43_316 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_28_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_13_208 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkload0 clknet_4_1_0_sys_clk VGND VGND VPWR VPWR clkload0/Y sky130_fd_sc_hd__bufinv_16
XFILLER_59_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout270 net2 VGND VGND VPWR VPWR net270 sky130_fd_sc_hd__clkbuf_1
XPHY_EDGE_ROW_28_Left_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1850_ _0291_ _0293_ VGND VGND VPWR VPWR _0298_ sky130_fd_sc_hd__or2_1
X_1781_ unlock_timer\[2\] unlock_timer\[1\] _0241_ VGND VGND VPWR VPWR _0245_ sky130_fd_sc_hd__and3_1
XFILLER_6_294 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1215_ dco_inst.accumulator\[24\] net83 VGND VGND VPWR VPWR _0606_ sky130_fd_sc_hd__or2_1
X_2195_ net213 _0126_ VGND VGND VPWR VPWR div_inst.counter\[12\] sky130_fd_sc_hd__dfxtp_1
X_1146_ _0544_ _0545_ _0541_ _0542_ VGND VGND VPWR VPWR _0547_ sky130_fd_sc_hd__o211ai_2
XFILLER_60_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_52_102 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1077_ dco_inst.accumulator\[5\] net94 VGND VGND VPWR VPWR _0487_ sky130_fd_sc_hd__or2_1
XFILLER_1_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1979_ _0403_ _0404_ _0407_ VGND VGND VPWR VPWR _0409_ sky130_fd_sc_hd__a21oi_1
XFILLER_20_36 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold23 net90 VGND VGND VPWR VPWR net298 sky130_fd_sc_hd__dlygate4sd3_1
Xhold45 net80 VGND VGND VPWR VPWR net320 sky130_fd_sc_hd__dlygate4sd3_1
Xhold12 pfd_inst.state\[1\] VGND VGND VPWR VPWR net287 sky130_fd_sc_hd__dlygate4sd3_1
Xhold56 lf_inst.integrator\[16\] VGND VGND VPWR VPWR net331 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_29_12 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xhold34 lf_inst.integrator\[10\] VGND VGND VPWR VPWR net309 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_45_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_45_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_43_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_28_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_6_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_10_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_49_425 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_32_325 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1902_ _0992_ _0336_ net202 _0987_ VGND VGND VPWR VPWR _0342_ sky130_fd_sc_hd__a2bb2o_1
X_1764_ _0230_ _0231_ VGND VGND VPWR VPWR _0232_ sky130_fd_sc_hd__nand2_1
X_1833_ _0281_ _0283_ VGND VGND VPWR VPWR _0284_ sky130_fd_sc_hd__or2_1
X_1695_ net237 net46 VGND VGND VPWR VPWR _0172_ sky130_fd_sc_hd__and2_1
X_2178_ clknet_4_11_0_sys_clk _0109_ VGND VGND VPWR VPWR net86 sky130_fd_sc_hd__dfxtp_1
XFILLER_25_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1129_ dco_inst.accumulator\[12\] net70 VGND VGND VPWR VPWR _0532_ sky130_fd_sc_hd__nor2_1
XFILLER_31_24 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_56_32 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_46_406 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xoutput79 net79 VGND VGND VPWR VPWR debug_dco_word[20] sky130_fd_sc_hd__buf_2
Xoutput68 net68 VGND VGND VPWR VPWR debug_dco_word[10] sky130_fd_sc_hd__buf_2
XFILLER_0_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_31_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_19_Right_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1480_ div_inst.counter\[21\] _0826_ VGND VGND VPWR VPWR _0863_ sky130_fd_sc_hd__xnor2_1
XPHY_EDGE_ROW_28_Right_28 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_37_Right_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2101_ clknet_4_1_0_sys_clk _0039_ VGND VGND VPWR VPWR lf_inst.integrator\[3\] sky130_fd_sc_hd__dfxtp_1
X_2032_ _0914_ net102 VGND VGND VPWR VPWR _0118_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_60_497 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_46_Right_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1747_ lf_inst.integrator\[24\] lf_inst.integrator\[25\] lf_inst.integrator\[26\]
+ lf_inst.integrator\[27\] net199 VGND VGND VPWR VPWR _0217_ sky130_fd_sc_hd__o41a_1
X_1678_ net237 net43 VGND VGND VPWR VPWR _0157_ sky130_fd_sc_hd__and2_1
XFILLER_7_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_15_Left_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1816_ net247 _0268_ _0037_ VGND VGND VPWR VPWR _0269_ sky130_fd_sc_hd__a21oi_1
XPHY_EDGE_ROW_55_Right_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_13_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_42_34 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_5_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_8_164 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_8_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1601_ lf_inst.integrator\[10\] net144 VGND VGND VPWR VPWR _0973_ sky130_fd_sc_hd__or2_1
X_1532_ net28 _0914_ VGND VGND VPWR VPWR _0915_ sky130_fd_sc_hd__or2_1
X_1463_ _0833_ _0845_ VGND VGND VPWR VPWR _0846_ sky130_fd_sc_hd__nand2b_1
XFILLER_27_208 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1394_ net267 _0659_ net26 VGND VGND VPWR VPWR _0777_ sky130_fd_sc_hd__o21ai_1
X_2015_ net193 _0233_ VGND VGND VPWR VPWR _0439_ sky130_fd_sc_hd__and2_1
XFILLER_35_263 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_50_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_58_333 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_37_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_26_263 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_17_230 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_19_247 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_27_291 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1515_ div_inst.counter\[10\] _0815_ VGND VGND VPWR VPWR _0898_ sky130_fd_sc_hd__xnor2_2
XTAP_TAPCELL_ROW_10_191 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_55_303 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1446_ _0827_ _0828_ VGND VGND VPWR VPWR _0829_ sky130_fd_sc_hd__and2_1
X_1377_ div_inst.counter\[10\] _0752_ _0755_ div_inst.counter\[9\] _0756_ VGND VGND
+ VPWR VPWR _0760_ sky130_fd_sc_hd__a221oi_2
XFILLER_23_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_58_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_45_Left_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_46_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_16_228 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_54_Left_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_9_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_24_272 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1231_ _0607_ _0616_ _0619_ net238 VGND VGND VPWR VPWR _0621_ sky130_fd_sc_hd__a31o_1
X_1300_ _0677_ _0682_ VGND VGND VPWR VPWR _0683_ sky130_fd_sc_hd__and2_1
XFILLER_49_130 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1162_ dco_inst.accumulator\[17\] net75 VGND VGND VPWR VPWR _0560_ sky130_fd_sc_hd__nor2_1
X_1093_ _0487_ _0493_ _0495_ _0492_ VGND VGND VPWR VPWR _0501_ sky130_fd_sc_hd__a31o_1
XFILLER_20_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_20_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1995_ _0418_ _0419_ _0417_ VGND VGND VPWR VPWR _0422_ sky130_fd_sc_hd__o21ba_1
XFILLER_9_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_20_258 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1429_ div_inst.counter\[7\] div_inst.counter\[6\] VGND VGND VPWR VPWR _0812_ sky130_fd_sc_hd__and2_1
XFILLER_55_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_55_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_7_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_7_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_13_209 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkload1 clknet_4_2_0_sys_clk VGND VGND VPWR VPWR clkload1/Y sky130_fd_sc_hd__clkinvlp_4
XFILLER_1_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout260 net261 VGND VGND VPWR VPWR net260 sky130_fd_sc_hd__buf_1
Xfanout271 net2 VGND VGND VPWR VPWR net271 sky130_fd_sc_hd__buf_1
XPHY_EDGE_ROW_3_Left_64 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_46_155 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_6_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_10_280 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1780_ _0452_ unlock_timer\[1\] unlock_timer\[0\] unlock_timer\[2\] VGND VGND VPWR
+ VPWR _0244_ sky130_fd_sc_hd__a31o_1
XFILLER_34_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1214_ _0601_ _0602_ _0604_ _0605_ VGND VGND VPWR VPWR _0027_ sky130_fd_sc_hd__a31oi_1
XFILLER_37_155 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_37_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2194_ net213 _0125_ VGND VGND VPWR VPWR div_inst.counter\[11\] sky130_fd_sc_hd__dfxtp_1
X_1145_ _0541_ _0542_ _0544_ _0545_ VGND VGND VPWR VPWR _0546_ sky130_fd_sc_hd__a211o_1
X_1076_ _0486_ net242 _0485_ VGND VGND VPWR VPWR _0008_ sky130_fd_sc_hd__and3b_1
X_1978_ _0403_ _0404_ _0407_ VGND VGND VPWR VPWR _0408_ sky130_fd_sc_hd__and3_1
XFILLER_20_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_20_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xhold35 net76 VGND VGND VPWR VPWR net310 sky130_fd_sc_hd__dlygate4sd3_1
Xhold13 lf_inst.integrator\[18\] VGND VGND VPWR VPWR net288 sky130_fd_sc_hd__dlygate4sd3_1
Xhold46 lf_inst.integrator\[17\] VGND VGND VPWR VPWR net321 sky130_fd_sc_hd__dlygate4sd3_1
Xhold24 dco_inst.accumulator\[0\] VGND VGND VPWR VPWR net299 sky130_fd_sc_hd__dlygate4sd3_1
Xhold57 net70 VGND VGND VPWR VPWR net332 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_43_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_43_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_16_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_57_470 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_49_426 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1832_ lf_inst.integrator\[3\] net137 VGND VGND VPWR VPWR _0283_ sky130_fd_sc_hd__nor2_1
XFILLER_15_350 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1901_ net142 _1002_ VGND VGND VPWR VPWR _0341_ sky130_fd_sc_hd__xnor2_1
X_1763_ net192 lf_inst.integrator\[30\] VGND VGND VPWR VPWR _0231_ sky130_fd_sc_hd__or2_1
X_1694_ net169 _0170_ VGND VGND VPWR VPWR _0171_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_40_370 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2177_ clknet_4_14_0_sys_clk _0108_ VGND VGND VPWR VPWR net85 sky130_fd_sc_hd__dfxtp_1
XFILLER_25_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_25_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1128_ _0529_ _0530_ VGND VGND VPWR VPWR _0531_ sky130_fd_sc_hd__and2_1
X_1059_ dco_inst.accumulator\[2\] net89 VGND VGND VPWR VPWR _0472_ sky130_fd_sc_hd__or2_1
XFILLER_31_36 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_31_14 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xoutput69 net69 VGND VGND VPWR VPWR debug_dco_word[11] sky130_fd_sc_hd__buf_2
XFILLER_56_88 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_56_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_46_407 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_31_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2100_ clknet_4_2_0_sys_clk _0038_ VGND VGND VPWR VPWR lf_inst.integrator\[2\] sky130_fd_sc_hd__dfxtp_1
X_2031_ _0903_ net101 VGND VGND VPWR VPWR _0117_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_60_498 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1815_ net223 net207 net203 VGND VGND VPWR VPWR _0268_ sky130_fd_sc_hd__nor3b_1
XFILLER_22_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1746_ _0214_ _0215_ VGND VGND VPWR VPWR _0216_ sky130_fd_sc_hd__and2_1
X_1677_ _1026_ _1030_ _0153_ VGND VGND VPWR VPWR _0156_ sky130_fd_sc_hd__a21o_1
XFILLER_7_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_45_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_13_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_42_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_5_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_8_176 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_36_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_29_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_44_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_32_Left_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_8_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_12_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1462_ div_inst.counter\[26\] _0829_ _0830_ div_inst.counter\[27\] VGND VGND VPWR
+ VPWR _0845_ sky130_fd_sc_hd__a31o_1
X_1531_ div_inst.counter\[4\] _0809_ VGND VGND VPWR VPWR _0914_ sky130_fd_sc_hd__xnor2_1
X_1600_ lf_inst.integrator\[10\] net144 VGND VGND VPWR VPWR _0972_ sky130_fd_sc_hd__and2_1
X_1393_ _0765_ _0768_ _0772_ _0775_ VGND VGND VPWR VPWR _0776_ sky130_fd_sc_hd__and4_1
X_2014_ net307 net157 _0437_ _0438_ _0228_ VGND VGND VPWR VPWR _0111_ sky130_fd_sc_hd__a221o_1
XFILLER_12_16 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1729_ lf_inst.integrator\[25\] net158 _0200_ _0201_ VGND VGND VPWR VPWR _0062_ sky130_fd_sc_hd__a211o_1
XFILLER_58_345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_37_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_37_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_18_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_41_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_41_245 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_41_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_26_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_1_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_27_292 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_17_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_17_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_17_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1445_ div_inst.counter\[23\] net117 VGND VGND VPWR VPWR _0828_ sky130_fd_sc_hd__and2_1
X_1514_ _0815_ _0896_ VGND VGND VPWR VPWR _0897_ sky130_fd_sc_hd__or2_1
XFILLER_4_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_10_192 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_55_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_55_315 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1376_ div_inst.counter\[8\] _0757_ VGND VGND VPWR VPWR _0759_ sky130_fd_sc_hd__nand2_1
XFILLER_58_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_58_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_46_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_16_229 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_9_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_13_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_14_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_24_273 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1230_ _0607_ _0616_ _0619_ VGND VGND VPWR VPWR _0620_ sky130_fd_sc_hd__a21oi_1
XFILLER_49_142 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_37_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_37_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_29_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1161_ _0554_ _0558_ _0559_ VGND VGND VPWR VPWR _0020_ sky130_fd_sc_hd__o21a_1
X_1092_ _0498_ _0499_ VGND VGND VPWR VPWR _0500_ sky130_fd_sc_hd__and2_1
X_1994_ _0212_ net133 VGND VGND VPWR VPWR _0421_ sky130_fd_sc_hd__xnor2_1
XFILLER_9_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1428_ div_inst.counter\[6\] _0810_ VGND VGND VPWR VPWR _0811_ sky130_fd_sc_hd__nand2_1
XFILLER_55_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1359_ div_inst.counter\[14\] _0739_ _0741_ net118 VGND VGND VPWR VPWR _0742_ sky130_fd_sc_hd__a22o_1
XFILLER_34_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_18_37 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_7_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkload2 clknet_4_3_0_sys_clk VGND VGND VPWR VPWR clkload2/Y sky130_fd_sc_hd__inv_6
XTAP_TAPCELL_ROW_21_254 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout272 net19 VGND VGND VPWR VPWR net272 sky130_fd_sc_hd__buf_1
Xfanout261 net66 VGND VGND VPWR VPWR net261 sky130_fd_sc_hd__buf_1
Xfanout250 net251 VGND VGND VPWR VPWR net250 sky130_fd_sc_hd__clkbuf_1
X_1213_ _0594_ _0600_ _0603_ net238 VGND VGND VPWR VPWR _0605_ sky130_fd_sc_hd__a31o_1
X_2193_ net214 _0124_ VGND VGND VPWR VPWR div_inst.counter\[10\] sky130_fd_sc_hd__dfxtp_2
X_1075_ _0481_ _0483_ _0484_ VGND VGND VPWR VPWR _0486_ sky130_fd_sc_hd__and3_1
XFILLER_1_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1144_ _0533_ _0537_ _0536_ VGND VGND VPWR VPWR _0545_ sky130_fd_sc_hd__a21boi_1
X_1977_ _0405_ _0406_ VGND VGND VPWR VPWR _0407_ sky130_fd_sc_hd__nand2b_1
XTAP_TAPCELL_ROW_43_390 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold36 lf_inst.integrator\[23\] VGND VGND VPWR VPWR net311 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_29_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_28_112 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold58 net74 VGND VGND VPWR VPWR net333 sky130_fd_sc_hd__dlygate4sd3_1
Xhold47 net92 VGND VGND VPWR VPWR net322 sky130_fd_sc_hd__dlygate4sd3_1
Xhold25 _0004_ VGND VGND VPWR VPWR net300 sky130_fd_sc_hd__dlygate4sd3_1
Xhold14 lf_inst.integrator\[3\] VGND VGND VPWR VPWR net289 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_51_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_43_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_6_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_59_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_57_471 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_49_427 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_34_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_19_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_40_371 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1831_ _0274_ _0277_ _0273_ VGND VGND VPWR VPWR _0282_ sky130_fd_sc_hd__o21ai_1
X_1900_ net146 _1002_ VGND VGND VPWR VPWR _0340_ sky130_fd_sc_hd__nand2_1
X_1762_ net192 lf_inst.integrator\[30\] VGND VGND VPWR VPWR _0230_ sky130_fd_sc_hd__nand2_1
X_1693_ _0168_ _0169_ VGND VGND VPWR VPWR _0170_ sky130_fd_sc_hd__xnor2_2
XFILLER_57_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2176_ clknet_4_14_0_sys_clk _0107_ VGND VGND VPWR VPWR net84 sky130_fd_sc_hd__dfxtp_1
XFILLER_40_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_33_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_25_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1127_ _0498_ _0502_ _0517_ _0520_ _0525_ VGND VGND VPWR VPWR _0530_ sky130_fd_sc_hd__a2111o_1
X_1058_ dco_inst.accumulator\[2\] net89 VGND VGND VPWR VPWR _0471_ sky130_fd_sc_hd__nand2_1
XFILLER_31_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_1_Right_1 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_56_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_56_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_46_408 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_54_452 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_8_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_8_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_4_3_0_sys_clk clknet_0_sys_clk VGND VGND VPWR VPWR clknet_4_3_0_sys_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_39_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2030_ _0905_ net101 VGND VGND VPWR VPWR _0116_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_60_499 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_60_488 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1745_ net195 lf_inst.integrator\[28\] VGND VGND VPWR VPWR _0215_ sky130_fd_sc_hd__nand2_1
XFILLER_30_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1814_ _0266_ _0267_ VGND VGND VPWR VPWR _0082_ sky130_fd_sc_hd__and2_1
X_1676_ _1026_ _1030_ _0153_ VGND VGND VPWR VPWR _0155_ sky130_fd_sc_hd__nand3_1
XFILLER_38_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2159_ clknet_4_4_0_sys_clk _0090_ VGND VGND VPWR VPWR net97 sky130_fd_sc_hd__dfxtp_1
XFILLER_53_287 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_42_14 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_8_177 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_16_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1461_ div_inst.counter\[28\] _0833_ VGND VGND VPWR VPWR _0844_ sky130_fd_sc_hd__xnor2_1
X_1530_ net267 _0907_ _0908_ _0911_ _0912_ VGND VGND VPWR VPWR _0913_ sky130_fd_sc_hd__a311o_1
X_1392_ net120 _0771_ _0773_ VGND VGND VPWR VPWR _0775_ sky130_fd_sc_hd__a21oi_1
X_2013_ _0428_ _0432_ _0436_ net170 VGND VGND VPWR VPWR _0438_ sky130_fd_sc_hd__a31oi_1
XFILLER_50_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_50_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_35_254 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1728_ net235 net50 VGND VGND VPWR VPWR _0201_ sky130_fd_sc_hd__and2_1
XFILLER_2_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_58_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1659_ net231 net41 VGND VGND VPWR VPWR _1024_ sky130_fd_sc_hd__and2_1
XTAP_TAPCELL_ROW_5_158 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_26_210 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_53_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_41_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_27_293 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_57_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_10_193 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1444_ div_inst.counter\[21\] div_inst.counter\[20\] net114 _0824_ VGND VGND VPWR
+ VPWR _0827_ sky130_fd_sc_hd__and4_1
X_1513_ div_inst.counter\[8\] _0813_ div_inst.counter\[9\] VGND VGND VPWR VPWR _0896_
+ sky130_fd_sc_hd__a21oi_1
X_1375_ div_inst.counter\[9\] _0755_ _0757_ div_inst.counter\[8\] VGND VGND VPWR VPWR
+ _0758_ sky130_fd_sc_hd__o22a_1
XFILLER_55_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_55_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_2_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_58_110 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_14_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_13_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_24_274 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_49_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_37_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1160_ _0554_ _0558_ net231 VGND VGND VPWR VPWR _0559_ sky130_fd_sc_hd__a21oi_1
X_1091_ dco_inst.accumulator\[7\] net96 VGND VGND VPWR VPWR _0499_ sky130_fd_sc_hd__or2_1
X_1993_ net313 net162 _0420_ net178 _0209_ VGND VGND VPWR VPWR _0108_ sky130_fd_sc_hd__a221o_1
X_1358_ net5 _0666_ VGND VGND VPWR VPWR _0741_ sky130_fd_sc_hd__xor2_1
XFILLER_18_16 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_18_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1427_ div_inst.counter\[5\] net120 _0809_ VGND VGND VPWR VPWR _0810_ sky130_fd_sc_hd__and3_1
XFILLER_55_146 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1289_ net14 net13 net277 net115 VGND VGND VPWR VPWR _0672_ sky130_fd_sc_hd__or4_2
Xclkload3 clknet_4_4_0_sys_clk VGND VGND VPWR VPWR clkload3/Y sky130_fd_sc_hd__bufinv_16
XTAP_TAPCELL_ROW_21_255 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_59_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xfanout240 _0453_ VGND VGND VPWR VPWR net240 sky130_fd_sc_hd__buf_1
Xfanout273 net19 VGND VGND VPWR VPWR net273 sky130_fd_sc_hd__clkbuf_1
Xfanout262 net5 VGND VGND VPWR VPWR net262 sky130_fd_sc_hd__buf_1
Xfanout251 net261 VGND VGND VPWR VPWR net251 sky130_fd_sc_hd__clkbuf_2
XTAP_TAPCELL_ROW_12_200 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_24_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_41_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_6_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1212_ _0594_ _0600_ VGND VGND VPWR VPWR _0604_ sky130_fd_sc_hd__nand2_1
XFILLER_37_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2192_ net213 _0123_ VGND VGND VPWR VPWR div_inst.counter\[9\] sky130_fd_sc_hd__dfxtp_1
XFILLER_52_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1074_ _0481_ _0483_ _0484_ VGND VGND VPWR VPWR _0485_ sky130_fd_sc_hd__a21o_1
X_1143_ _0529_ _0530_ _0543_ VGND VGND VPWR VPWR _0544_ sky130_fd_sc_hd__a21boi_4
XFILLER_60_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1976_ _0195_ net128 VGND VGND VPWR VPWR _0406_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_43_391 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold59 net83 VGND VGND VPWR VPWR net334 sky130_fd_sc_hd__dlygate4sd3_1
Xhold15 lf_inst.integrator\[30\] VGND VGND VPWR VPWR net290 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_43_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xhold37 pfd_inst.state\[2\] VGND VGND VPWR VPWR net312 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_29_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_28_124 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold48 net89 VGND VGND VPWR VPWR net323 sky130_fd_sc_hd__dlygate4sd3_1
Xhold26 net73 VGND VGND VPWR VPWR net301 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_51_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_51_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_24_352 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_3_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_3_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_19_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_57_472 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_34_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_34_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1761_ _0219_ _0225_ _0224_ _0215_ VGND VGND VPWR VPWR _0229_ sky130_fd_sc_hd__o211a_1
XTAP_TAPCELL_ROW_40_372 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_30_355 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1830_ _0280_ VGND VGND VPWR VPWR _0281_ sky130_fd_sc_hd__inv_2
X_1692_ _0161_ _0164_ _0160_ VGND VGND VPWR VPWR _0169_ sky130_fd_sc_hd__a21o_1
X_2175_ clknet_4_14_0_sys_clk _0106_ VGND VGND VPWR VPWR net83 sky130_fd_sc_hd__dfxtp_1
X_1126_ _0516_ _0523_ _0524_ _0528_ VGND VGND VPWR VPWR _0529_ sky130_fd_sc_hd__o211a_1
XFILLER_33_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1057_ _0470_ net243 _0469_ VGND VGND VPWR VPWR _0005_ sky130_fd_sc_hd__and3b_1
X_1959_ _0178_ net129 VGND VGND VPWR VPWR _0391_ sky130_fd_sc_hd__nor2_1
XFILLER_0_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_56_274 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_56_230 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_54_453 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_409 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_8_326 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_21_60 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_4_7_0_sys_clk clknet_0_sys_clk VGND VGND VPWR VPWR clknet_4_7_0_sys_clk sky130_fd_sc_hd__clkbuf_8
XTAP_TAPCELL_ROW_60_489 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1744_ net194 lf_inst.integrator\[28\] VGND VGND VPWR VPWR _0214_ sky130_fd_sc_hd__or2_1
XFILLER_30_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1813_ lf_inst.zero_error_count\[3\] net205 _0261_ lf_inst.zero_error_count\[4\]
+ VGND VGND VPWR VPWR _0267_ sky130_fd_sc_hd__a31o_1
XFILLER_7_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1675_ _0153_ VGND VGND VPWR VPWR _0154_ sky130_fd_sc_hd__inv_2
XPHY_EDGE_ROW_15_Right_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2089_ clknet_4_14_0_sys_clk _0030_ VGND VGND VPWR VPWR dco_inst.accumulator\[26\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_53_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_24_Right_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1109_ net249 _0513_ _0514_ VGND VGND VPWR VPWR _0013_ sky130_fd_sc_hd__and3_1
X_2158_ clknet_4_1_0_sys_clk _0089_ VGND VGND VPWR VPWR net96 sky130_fd_sc_hd__dfxtp_1
XFILLER_53_299 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_51_434 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_42_48 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_33_Right_33 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_8_178 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_42_Right_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_16_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_51_Right_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_8_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1460_ net24 _0842_ VGND VGND VPWR VPWR _0843_ sky130_fd_sc_hd__or2_1
X_1391_ _0772_ _0773_ _0768_ VGND VGND VPWR VPWR _0774_ sky130_fd_sc_hd__o21ai_1
XPHY_EDGE_ROW_60_Right_60 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2012_ _0428_ _0432_ _0436_ VGND VGND VPWR VPWR _0437_ sky130_fd_sc_hd__a21o_1
XFILLER_35_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1727_ net170 _0199_ VGND VGND VPWR VPWR _0200_ sky130_fd_sc_hd__nor2_1
X_1658_ _1021_ _1022_ VGND VGND VPWR VPWR _1023_ sky130_fd_sc_hd__nand2_1
XFILLER_12_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_5_159 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1589_ lf_inst.integrator\[9\] _0961_ VGND VGND VPWR VPWR _0962_ sky130_fd_sc_hd__and2_1
XFILLER_53_36 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_41_236 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_26_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_43_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_27_294 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1512_ net262 _0891_ _0894_ net4 VGND VGND VPWR VPWR _0895_ sky130_fd_sc_hd__o22a_1
X_1443_ div_inst.counter\[20\] net114 _0824_ VGND VGND VPWR VPWR _0826_ sky130_fd_sc_hd__and3_1
XFILLER_4_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1374_ net31 _0663_ VGND VGND VPWR VPWR _0757_ sky130_fd_sc_hd__xnor2_1
XFILLER_23_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_58_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_58_122 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_46_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_46_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_24_275 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_14_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_49_100 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_36_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_52_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1090_ dco_inst.accumulator\[7\] net96 VGND VGND VPWR VPWR _0498_ sky130_fd_sc_hd__nand2_1
X_1992_ _0418_ _0419_ VGND VGND VPWR VPWR _0420_ sky130_fd_sc_hd__xor2_1
Xclkload10 clknet_4_11_0_sys_clk VGND VGND VPWR VPWR clkload10/Y sky130_fd_sc_hd__clkinvlp_4
XPHY_EDGE_ROW_41_Left_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_15_220 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_55_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_50_Left_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1288_ net13 net277 net115 VGND VGND VPWR VPWR _0671_ sky130_fd_sc_hd__or3_1
X_1357_ div_inst.counter\[15\] _0737_ _0739_ div_inst.counter\[14\] VGND VGND VPWR
+ VPWR _0740_ sky130_fd_sc_hd__o22a_1
X_1426_ net123 net122 div_inst.counter\[3\] net121 VGND VGND VPWR VPWR _0809_ sky130_fd_sc_hd__and4_1
XTAP_TAPCELL_ROW_38_356 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_239 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_50_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkload4 clknet_4_5_0_sys_clk VGND VGND VPWR VPWR clkload4/Y sky130_fd_sc_hd__clkinvlp_4
XTAP_TAPCELL_ROW_21_256 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout274 net18 VGND VGND VPWR VPWR net274 sky130_fd_sc_hd__buf_1
Xfanout252 net256 VGND VGND VPWR VPWR net252 sky130_fd_sc_hd__clkbuf_2
Xfanout241 net8 VGND VGND VPWR VPWR net241 sky130_fd_sc_hd__buf_1
Xfanout230 net232 VGND VGND VPWR VPWR net230 sky130_fd_sc_hd__dlymetal6s2s_1
Xfanout263 net30 VGND VGND VPWR VPWR net263 sky130_fd_sc_hd__buf_1
XFILLER_46_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_46_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_34_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_12_201 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_40_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_40_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_6_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1211_ _0601_ _0602_ VGND VGND VPWR VPWR _0603_ sky130_fd_sc_hd__nand2_1
XFILLER_37_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_37_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1142_ _0534_ _0536_ _0537_ VGND VGND VPWR VPWR _0543_ sky130_fd_sc_hd__and3_1
X_2191_ net213 _0122_ VGND VGND VPWR VPWR div_inst.counter\[8\] sky130_fd_sc_hd__dfxtp_1
XFILLER_60_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1073_ _0477_ _0478_ _0476_ VGND VGND VPWR VPWR _0484_ sky130_fd_sc_hd__a21bo_1
X_1975_ _0195_ net128 VGND VGND VPWR VPWR _0405_ sky130_fd_sc_hd__nor2_1
XFILLER_20_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xhold38 net85 VGND VGND VPWR VPWR net313 sky130_fd_sc_hd__dlygate4sd3_1
Xhold16 lf_inst.integrator\[28\] VGND VGND VPWR VPWR net291 sky130_fd_sc_hd__dlygate4sd3_1
Xhold27 net79 VGND VGND VPWR VPWR net302 sky130_fd_sc_hd__dlygate4sd3_1
X_1409_ _0743_ _0791_ VGND VGND VPWR VPWR _0792_ sky130_fd_sc_hd__or2_1
XFILLER_28_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xhold49 net68 VGND VGND VPWR VPWR net324 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_16_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_7_Left_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_3_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_19_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_57_473 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_35_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_30_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1760_ net293 net156 _0227_ net175 _0228_ VGND VGND VPWR VPWR _0066_ sky130_fd_sc_hd__a221o_1
X_1691_ net198 lf_inst.integrator\[21\] VGND VGND VPWR VPWR _0168_ sky130_fd_sc_hd__xor2_2
XTAP_TAPCELL_ROW_40_373 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2174_ clknet_4_15_0_sys_clk _0105_ VGND VGND VPWR VPWR net82 sky130_fd_sc_hd__dfxtp_1
X_1125_ _0517_ _0525_ _0519_ VGND VGND VPWR VPWR _0528_ sky130_fd_sc_hd__or3b_1
XFILLER_33_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1056_ dco_inst.accumulator\[0\] net210 _0467_ _0468_ VGND VGND VPWR VPWR _0470_
+ sky130_fd_sc_hd__and4_1
XFILLER_15_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_21_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1958_ net320 net161 _0390_ net179 _0172_ VGND VGND VPWR VPWR _0103_ sky130_fd_sc_hd__a221o_1
X_1889_ _0982_ net134 _0330_ VGND VGND VPWR VPWR _0331_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_56_286 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_56_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_54_454 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_16_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_21_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_47_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_39_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_46_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_30_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_15_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1743_ net326 net158 _0212_ net177 _0213_ VGND VGND VPWR VPWR _0064_ sky130_fd_sc_hd__a221o_1
X_1674_ _0151_ _0152_ VGND VGND VPWR VPWR _0153_ sky130_fd_sc_hd__nand2_1
X_1812_ _0451_ _0254_ _0262_ _0265_ _0266_ VGND VGND VPWR VPWR _0081_ sky130_fd_sc_hd__o311a_1
X_2088_ clknet_4_15_0_sys_clk _0029_ VGND VGND VPWR VPWR dco_inst.accumulator\[25\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_53_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1039_ _0458_ VGND VGND VPWR VPWR _0459_ sky130_fd_sc_hd__inv_2
X_1108_ _0505_ _0507_ _0509_ _0511_ VGND VGND VPWR VPWR _0514_ sky130_fd_sc_hd__a211o_1
X_2157_ clknet_4_1_0_sys_clk _0088_ VGND VGND VPWR VPWR net95 sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_51_435 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_42_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_5_308 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_44_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_8_179 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_44_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_12_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_8_146 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_8_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1390_ div_inst.counter\[6\] _0767_ _0769_ div_inst.counter\[5\] VGND VGND VPWR VPWR
+ _0773_ sky130_fd_sc_hd__a22o_1
X_2011_ _0227_ _0434_ VGND VGND VPWR VPWR _0436_ sky130_fd_sc_hd__xnor2_1
XFILLER_35_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1726_ _0197_ _0198_ VGND VGND VPWR VPWR _0199_ sky130_fd_sc_hd__xnor2_2
X_1657_ _1015_ _1013_ _1020_ VGND VGND VPWR VPWR _1022_ sky130_fd_sc_hd__a21bo_1
X_1588_ net223 net203 VGND VGND VPWR VPWR _0961_ sky130_fd_sc_hd__and2b_1
X_2209_ net219 _0140_ VGND VGND VPWR VPWR div_inst.counter\[26\] sky130_fd_sc_hd__dfxtp_1
XFILLER_37_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_53_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_26_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_5_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_36_Left_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_27_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_27_295 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1442_ net114 _0824_ VGND VGND VPWR VPWR _0825_ sky130_fd_sc_hd__and2_1
X_1511_ _0817_ _0893_ VGND VGND VPWR VPWR _0894_ sky130_fd_sc_hd__nand2_1
XFILLER_4_182 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1373_ div_inst.counter\[11\] _0665_ _0750_ VGND VGND VPWR VPWR _0756_ sky130_fd_sc_hd__and3_1
XFILLER_4_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_18_240 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_23_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_31_292 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1709_ _0182_ _0183_ VGND VGND VPWR VPWR _0184_ sky130_fd_sc_hd__xnor2_1
XFILLER_58_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_24_276 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_60_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_15_221 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1991_ _0412_ _0414_ _0413_ VGND VGND VPWR VPWR _0419_ sky130_fd_sc_hd__o21ba_1
Xclkload11 clknet_4_12_0_sys_clk VGND VGND VPWR VPWR clkload11/Y sky130_fd_sc_hd__inv_6
XFILLER_13_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_20_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1425_ net123 net122 net121 VGND VGND VPWR VPWR _0808_ sky130_fd_sc_hd__and3_1
XTAP_TAPCELL_ROW_38_357 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1287_ net10 net9 net241 _0668_ VGND VGND VPWR VPWR _0670_ sky130_fd_sc_hd__or4_1
X_1356_ _0667_ _0738_ VGND VGND VPWR VPWR _0739_ sky130_fd_sc_hd__and2_1
XFILLER_51_354 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_51_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_34_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkload5 clknet_4_6_0_sys_clk VGND VGND VPWR VPWR clkload5/Y sky130_fd_sc_hd__inv_6
XTAP_TAPCELL_ROW_21_257 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout275 net18 VGND VGND VPWR VPWR net275 sky130_fd_sc_hd__clkbuf_1
Xfanout220 net221 VGND VGND VPWR VPWR net220 sky130_fd_sc_hd__clkbuf_2
Xfanout253 net256 VGND VGND VPWR VPWR net253 sky130_fd_sc_hd__buf_1
Xfanout231 net232 VGND VGND VPWR VPWR net231 sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_29_302 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout264 net3 VGND VGND VPWR VPWR net264 sky130_fd_sc_hd__buf_1
Xfanout242 net244 VGND VGND VPWR VPWR net242 sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_19_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_46_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_46_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_42_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_10_240 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_10_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_12_202 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_6_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1210_ dco_inst.accumulator\[23\] net82 VGND VGND VPWR VPWR _0602_ sky130_fd_sc_hd__nand2_1
XFILLER_37_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_27_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1072_ dco_inst.accumulator\[4\] net93 VGND VGND VPWR VPWR _0483_ sky130_fd_sc_hd__or2_1
X_1141_ dco_inst.accumulator\[14\] net72 VGND VGND VPWR VPWR _0542_ sky130_fd_sc_hd__nand2_1
X_2190_ net211 _0121_ VGND VGND VPWR VPWR div_inst.counter\[7\] sky130_fd_sc_hd__dfxtp_1
XFILLER_60_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1974_ _0184_ net129 _0392_ _0395_ VGND VGND VPWR VPWR _0404_ sky130_fd_sc_hd__o211a_1
XFILLER_45_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_45_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_35_338 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_23_Left_84 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold39 net84 VGND VGND VPWR VPWR net314 sky130_fd_sc_hd__dlygate4sd3_1
Xhold17 lf_inst.integrator\[31\] VGND VGND VPWR VPWR net292 sky130_fd_sc_hd__dlygate4sd3_1
Xhold28 lf_inst.integrator\[22\] VGND VGND VPWR VPWR net303 sky130_fd_sc_hd__dlygate4sd3_1
X_1408_ _0742_ _0746_ _0740_ VGND VGND VPWR VPWR _0791_ sky130_fd_sc_hd__o21a_1
XFILLER_45_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1339_ div_inst.counter\[19\] _0721_ VGND VGND VPWR VPWR _0722_ sky130_fd_sc_hd__nand2_1
XFILLER_36_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_3_258 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_10_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_19_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_57_474 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_42_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_35_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_34_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_30_313 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_27_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1690_ net329 net160 _0166_ net180 _0167_ VGND VGND VPWR VPWR _0057_ sky130_fd_sc_hd__a221o_1
XFILLER_25_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2173_ clknet_4_14_0_sys_clk _0104_ VGND VGND VPWR VPWR net81 sky130_fd_sc_hd__dfxtp_1
X_1124_ _0526_ _0527_ VGND VGND VPWR VPWR _0015_ sky130_fd_sc_hd__nor2_1
X_1055_ dco_inst.accumulator\[0\] net209 _0467_ _0468_ VGND VGND VPWR VPWR _0469_
+ sky130_fd_sc_hd__a22o_1
X_1957_ _0388_ _0389_ VGND VGND VPWR VPWR _0390_ sky130_fd_sc_hd__xnor2_1
X_1888_ _0456_ _0963_ _0975_ net134 VGND VGND VPWR VPWR _0330_ sky130_fd_sc_hd__a31o_1
XFILLER_56_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_56_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_54_455 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_47_232 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_47_210 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_46_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_45_400 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_30_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_30_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1811_ net246 _0255_ VGND VGND VPWR VPWR _0266_ sky130_fd_sc_hd__and2_1
X_1742_ net235 net52 VGND VGND VPWR VPWR _0213_ sky130_fd_sc_hd__and2_1
X_1673_ net197 lf_inst.integrator\[19\] VGND VGND VPWR VPWR _0152_ sky130_fd_sc_hd__or2_1
X_2087_ clknet_4_15_0_sys_clk _0028_ VGND VGND VPWR VPWR dco_inst.accumulator\[24\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_53_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_51_436 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1038_ pfd_inst.fb_sync\[2\] pfd_inst.fb_sync\[1\] VGND VGND VPWR VPWR _0458_ sky130_fd_sc_hd__and2b_1
XFILLER_38_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_5_Right_5 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1107_ _0509_ _0511_ _0505_ _0507_ VGND VGND VPWR VPWR _0513_ sky130_fd_sc_hd__o211ai_1
X_2156_ clknet_4_0_0_sys_clk _0087_ VGND VGND VPWR VPWR net94 sky130_fd_sc_hd__dfxtp_1
XPHY_EDGE_ROW_10_Left_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_8_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_12_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2010_ _0227_ _0434_ VGND VGND VPWR VPWR _0435_ sky130_fd_sc_hd__nand2_1
XFILLER_50_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_35_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_35_202 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1725_ _0187_ _0194_ net196 lf_inst.integrator\[24\] VGND VGND VPWR VPWR _0198_ sky130_fd_sc_hd__a2bb2o_1
XFILLER_58_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1656_ _1020_ _1015_ _1013_ VGND VGND VPWR VPWR _1021_ sky130_fd_sc_hd__nand3b_1
X_1587_ net33 net209 net242 VGND VGND VPWR VPWR _0045_ sky130_fd_sc_hd__mux2_1
X_2208_ net218 _0139_ VGND VGND VPWR VPWR div_inst.counter\[25\] sky130_fd_sc_hd__dfxtp_1
X_2139_ clknet_4_8_0_sys_clk net282 net252 VGND VGND VPWR VPWR pfd_inst.ref_sync\[1\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_41_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_17_268 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_40_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1441_ div_inst.counter\[19\] div_inst.counter\[18\] VGND VGND VPWR VPWR _0824_ sky130_fd_sc_hd__and2_1
X_1510_ div_inst.counter\[10\] _0813_ _0814_ div_inst.counter\[11\] VGND VGND VPWR
+ VPWR _0893_ sky130_fd_sc_hd__a31o_1
XFILLER_4_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_4_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1372_ _0664_ _0754_ VGND VGND VPWR VPWR _0755_ sky130_fd_sc_hd__and2_1
XTAP_TAPCELL_ROW_18_241 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_23_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1708_ _0175_ _0177_ _0174_ VGND VGND VPWR VPWR _0183_ sky130_fd_sc_hd__a21o_1
X_1639_ _1004_ _1005_ VGND VGND VPWR VPWR _1006_ sky130_fd_sc_hd__xnor2_2
XTAP_TAPCELL_ROW_24_277 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_14_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_60_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1990_ _0207_ net131 VGND VGND VPWR VPWR _0418_ sky130_fd_sc_hd__xnor2_1
XTAP_TAPCELL_ROW_15_222 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_55_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkload12 clknet_4_13_0_sys_clk VGND VGND VPWR VPWR clkload12/Y sky130_fd_sc_hd__clkinv_4
XFILLER_9_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1424_ _0800_ _0806_ VGND VGND VPWR VPWR _0807_ sky130_fd_sc_hd__nand2_1
X_1355_ net262 _0666_ net6 VGND VGND VPWR VPWR _0738_ sky130_fd_sc_hd__o21ai_1
XFILLER_55_116 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_38_358 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1286_ net9 net241 _0668_ VGND VGND VPWR VPWR _0669_ sky130_fd_sc_hd__or3_1
XFILLER_34_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkload6 clknet_4_7_0_sys_clk VGND VGND VPWR VPWR clkload6/Y sky130_fd_sc_hd__clkinv_4
XTAP_TAPCELL_ROW_21_258 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_59_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout221 net222 VGND VGND VPWR VPWR net221 sky130_fd_sc_hd__buf_1
Xfanout276 net15 VGND VGND VPWR VPWR net276 sky130_fd_sc_hd__buf_1
Xfanout254 net255 VGND VGND VPWR VPWR net254 sky130_fd_sc_hd__dlymetal6s2s_1
XTAP_TAPCELL_ROW_29_303 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout232 net240 VGND VGND VPWR VPWR net232 sky130_fd_sc_hd__buf_1
Xfanout243 net244 VGND VGND VPWR VPWR net243 sky130_fd_sc_hd__clkbuf_1
Xfanout210 lf_inst.integrator\[0\] VGND VGND VPWR VPWR net210 sky130_fd_sc_hd__clkbuf_1
Xfanout265 net27 VGND VGND VPWR VPWR net265 sky130_fd_sc_hd__buf_1
XFILLER_6_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_12_203 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1071_ _0481_ VGND VGND VPWR VPWR _0482_ sky130_fd_sc_hd__inv_2
XFILLER_1_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1140_ dco_inst.accumulator\[14\] net72 VGND VGND VPWR VPWR _0541_ sky130_fd_sc_hd__or2_1
XFILLER_60_174 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_60_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_60_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1973_ _0382_ _0381_ _0388_ _0380_ _0190_ VGND VGND VPWR VPWR _0403_ sky130_fd_sc_hd__a2111o_1
XTAP_TAPCELL_ROW_35_339 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold18 lf_inst.integrator\[29\] VGND VGND VPWR VPWR net293 sky130_fd_sc_hd__dlygate4sd3_1
X_1338_ net11 net115 VGND VGND VPWR VPWR _0721_ sky130_fd_sc_hd__xor2_1
X_1407_ _0753_ _0756_ _0758_ _0761_ _0789_ VGND VGND VPWR VPWR _0790_ sky130_fd_sc_hd__o221a_1
Xhold29 lf_inst.integrator\[2\] VGND VGND VPWR VPWR net304 sky130_fd_sc_hd__dlygate4sd3_1
X_1269_ _0637_ _0642_ _0646_ _0652_ _0645_ VGND VGND VPWR VPWR _0654_ sky130_fd_sc_hd__a311o_1
XFILLER_3_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_10_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_59_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_57_475 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_15_311 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_19_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_42_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_30_325 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_15_322 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_51_60 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2172_ clknet_4_13_0_sys_clk _0103_ VGND VGND VPWR VPWR net80 sky130_fd_sc_hd__dfxtp_1
XFILLER_18_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_48_420 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_25_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1123_ _0516_ _0522_ _0525_ net228 VGND VGND VPWR VPWR _0527_ sky130_fd_sc_hd__a31o_1
X_1054_ dco_inst.accumulator\[1\] net78 VGND VGND VPWR VPWR _0468_ sky130_fd_sc_hd__or2_1
X_1956_ _0378_ _0383_ VGND VGND VPWR VPWR _0389_ sky130_fd_sc_hd__or2_1
X_1887_ _0317_ _0320_ VGND VGND VPWR VPWR _0329_ sky130_fd_sc_hd__and2_1
XFILLER_56_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_56_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_54_456 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_8_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_47_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_47_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_45_401 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1741_ _0210_ _0211_ VGND VGND VPWR VPWR _0212_ sky130_fd_sc_hd__xor2_1
XFILLER_30_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_30_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1810_ _0257_ _0261_ lf_inst.zero_error_count\[3\] VGND VGND VPWR VPWR _0265_ sky130_fd_sc_hd__a21o_1
X_1672_ net197 lf_inst.integrator\[19\] VGND VGND VPWR VPWR _0151_ sky130_fd_sc_hd__nand2_1
XFILLER_53_203 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_38_200 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2155_ clknet_4_1_0_sys_clk _0086_ VGND VGND VPWR VPWR net93 sky130_fd_sc_hd__dfxtp_1
X_1106_ dco_inst.accumulator\[9\] net184 VGND VGND VPWR VPWR _0512_ sky130_fd_sc_hd__nand2_1
X_2086_ clknet_4_15_0_sys_clk _0027_ VGND VGND VPWR VPWR dco_inst.accumulator\[23\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_53_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_51_437 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1037_ lf_inst.integrator\[12\] VGND VGND VPWR VPWR _0457_ sky130_fd_sc_hd__inv_2
X_1939_ _0373_ VGND VGND VPWR VPWR _0374_ sky130_fd_sc_hd__inv_2
XFILLER_44_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_4_13_0_sys_clk clknet_0_sys_clk VGND VGND VPWR VPWR clknet_4_13_0_sys_clk
+ sky130_fd_sc_hd__clkbuf_8
XFILLER_29_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_29_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_16_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_11_Right_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_16_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_20_Right_20 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_7_170 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_35_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_35_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1724_ net196 lf_inst.integrator\[25\] VGND VGND VPWR VPWR _0197_ sky130_fd_sc_hd__xor2_2
X_1655_ net189 lf_inst.integrator\[17\] VGND VGND VPWR VPWR _1020_ sky130_fd_sc_hd__xnor2_1
X_1586_ net63 lf_inst.integrator\[8\] net249 VGND VGND VPWR VPWR _0044_ sky130_fd_sc_hd__mux2_1
X_2207_ net218 _0138_ VGND VGND VPWR VPWR div_inst.counter\[24\] sky130_fd_sc_hd__dfxtp_1
X_2138_ clknet_4_8_0_sys_clk net65 net252 VGND VGND VPWR VPWR pfd_inst.ref_sync\[0\]
+ sky130_fd_sc_hd__dfrtp_1
X_2069_ clknet_4_0_0_sys_clk _0010_ VGND VGND VPWR VPWR dco_inst.accumulator\[6\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_53_28 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_41_228 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_41_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_1_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_17_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1440_ net118 _0818_ _0820_ _0822_ VGND VGND VPWR VPWR _0823_ sky130_fd_sc_hd__and4_1
XFILLER_4_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_4_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1371_ net263 net31 _0662_ net32 VGND VGND VPWR VPWR _0754_ sky130_fd_sc_hd__o31ai_1
XFILLER_31_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1707_ net198 lf_inst.integrator\[23\] VGND VGND VPWR VPWR _0182_ sky130_fd_sc_hd__xor2_1
X_1638_ _0995_ _1001_ _0996_ VGND VGND VPWR VPWR _1005_ sky130_fd_sc_hd__o21a_1
XFILLER_58_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1569_ _0900_ _0911_ _0926_ _0938_ VGND VGND VPWR VPWR _0952_ sky130_fd_sc_hd__and4_1
XFILLER_38_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_38_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_37_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_54_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_15_223 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkload13 clknet_4_14_0_sys_clk VGND VGND VPWR VPWR clkload13/Y sky130_fd_sc_hd__clkinv_4
XFILLER_9_298 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_48_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1423_ div_inst.counter\[31\] _0688_ _0691_ _0805_ VGND VGND VPWR VPWR _0806_ sky130_fd_sc_hd__a22oi_1
X_1354_ _0668_ _0736_ VGND VGND VPWR VPWR _0737_ sky130_fd_sc_hd__and2_1
X_1285_ net7 net262 net6 _0666_ VGND VGND VPWR VPWR _0668_ sky130_fd_sc_hd__or4_2
XFILLER_55_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_38_359 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_36_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_50_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkload7 clknet_4_8_0_sys_clk VGND VGND VPWR VPWR clkload7/Y sky130_fd_sc_hd__bufinv_16
XTAP_TAPCELL_ROW_21_259 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout222 net100 VGND VGND VPWR VPWR net222 sky130_fd_sc_hd__buf_1
Xfanout200 net201 VGND VGND VPWR VPWR net200 sky130_fd_sc_hd__buf_1
Xfanout211 net215 VGND VGND VPWR VPWR net211 sky130_fd_sc_hd__buf_1
Xfanout233 net234 VGND VGND VPWR VPWR net233 sky130_fd_sc_hd__buf_1
XFILLER_46_106 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout277 net11 VGND VGND VPWR VPWR net277 sky130_fd_sc_hd__buf_1
Xfanout255 net256 VGND VGND VPWR VPWR net255 sky130_fd_sc_hd__buf_1
XTAP_TAPCELL_ROW_29_304 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout244 net246 VGND VGND VPWR VPWR net244 sky130_fd_sc_hd__clkbuf_2
Xfanout266 net27 VGND VGND VPWR VPWR net266 sky130_fd_sc_hd__clkbuf_1
XFILLER_54_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_12_204 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_6_224 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_10_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1070_ dco_inst.accumulator\[4\] net93 VGND VGND VPWR VPWR _0481_ sky130_fd_sc_hd__nand2_1
XFILLER_60_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_60_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1972_ net82 net161 _0401_ _0402_ _0186_ VGND VGND VPWR VPWR _0105_ sky130_fd_sc_hd__a221o_1
XPHY_EDGE_ROW_49_Right_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_58_Right_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1268_ _0637_ _0642_ _0646_ _0645_ VGND VGND VPWR VPWR _0653_ sky130_fd_sc_hd__a31o_1
X_1337_ _0713_ _0715_ _0718_ _0719_ VGND VGND VPWR VPWR _0720_ sky130_fd_sc_hd__or4_1
Xhold19 lf_inst.integrator\[11\] VGND VGND VPWR VPWR net294 sky130_fd_sc_hd__dlygate4sd3_1
X_1406_ _0762_ _0788_ VGND VGND VPWR VPWR _0789_ sky130_fd_sc_hd__nand2_1
X_1199_ _0590_ _0591_ _0592_ VGND VGND VPWR VPWR _0025_ sky130_fd_sc_hd__a21oi_1
XFILLER_36_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_24_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_10_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_10_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_27_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_15_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_15_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_19_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_42_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_42_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_35_84 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_30_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_48_421 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2171_ clknet_4_12_0_sys_clk _0102_ VGND VGND VPWR VPWR net79 sky130_fd_sc_hd__dfxtp_1
XFILLER_32_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_2_260 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1122_ _0516_ _0522_ _0525_ VGND VGND VPWR VPWR _0526_ sky130_fd_sc_hd__a21oi_1
XFILLER_33_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1053_ dco_inst.accumulator\[1\] net78 VGND VGND VPWR VPWR _0467_ sky130_fd_sc_hd__nand2_1
XFILLER_21_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1955_ _0170_ net125 VGND VGND VPWR VPWR _0388_ sky130_fd_sc_hd__xnor2_1
X_1886_ _0987_ net135 VGND VGND VPWR VPWR _0328_ sky130_fd_sc_hd__xnor2_1
XFILLER_56_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_16_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_54_457 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_12_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_21_31 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_47_256 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_45_402 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1740_ net199 lf_inst.integrator\[26\] _0205_ VGND VGND VPWR VPWR _0211_ sky130_fd_sc_hd__a21bo_1
X_1671_ net288 net159 _0149_ _0150_ VGND VGND VPWR VPWR _0055_ sky130_fd_sc_hd__a211o_1
XFILLER_30_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_7_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_53_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2085_ clknet_4_15_0_sys_clk _0026_ VGND VGND VPWR VPWR dco_inst.accumulator\[22\]
+ sky130_fd_sc_hd__dfxtp_1
X_1105_ dco_inst.accumulator\[9\] net184 VGND VGND VPWR VPWR _0511_ sky130_fd_sc_hd__and2_1
X_2154_ clknet_4_0_0_sys_clk _0085_ VGND VGND VPWR VPWR net92 sky130_fd_sc_hd__dfxtp_1
XFILLER_53_259 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_51_438 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1036_ lf_inst.integrator\[8\] VGND VGND VPWR VPWR _0456_ sky130_fd_sc_hd__inv_2
XFILLER_21_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1938_ _0155_ _0156_ net132 VGND VGND VPWR VPWR _0373_ sky130_fd_sc_hd__nand3_1
X_1869_ lf_inst.integrator\[8\] net139 _0311_ VGND VGND VPWR VPWR _0314_ sky130_fd_sc_hd__a21oi_1
XPHY_EDGE_ROW_48_Left_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_29_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_12_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_16_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_57_Left_118 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_32_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_8_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_16_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_333 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_35_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_7_171 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_50_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_43_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1723_ net259 net49 net147 lf_inst.integrator\[24\] _0196_ VGND VGND VPWR VPWR _0061_
+ sky130_fd_sc_hd__o221a_1
X_1654_ net331 net147 _1018_ _1019_ VGND VGND VPWR VPWR _0053_ sky130_fd_sc_hd__o211a_1
X_2206_ net218 _0137_ VGND VGND VPWR VPWR div_inst.counter\[23\] sky130_fd_sc_hd__dfxtp_1
X_1585_ net245 net336 _0960_ VGND VGND VPWR VPWR _0043_ sky130_fd_sc_hd__a21o_1
X_2137_ clknet_4_2_0_sys_clk _0075_ VGND VGND VPWR VPWR unlock_timer\[5\] sky130_fd_sc_hd__dfxtp_1
X_2068_ clknet_4_0_0_sys_clk _0009_ VGND VGND VPWR VPWR dco_inst.accumulator\[5\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_49_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_49_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_27_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_4_152 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_25_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_4_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1370_ div_inst.counter\[10\] _0752_ _0751_ VGND VGND VPWR VPWR _0753_ sky130_fd_sc_hd__o21a_1
XFILLER_31_284 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_31_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1706_ net303 net161 _0179_ net178 _0180_ VGND VGND VPWR VPWR _0059_ sky130_fd_sc_hd__a221o_1
X_1637_ net188 lf_inst.integrator\[15\] VGND VGND VPWR VPWR _1004_ sky130_fd_sc_hd__xor2_2
XFILLER_54_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1499_ _0862_ _0881_ _0860_ VGND VGND VPWR VPWR _0882_ sky130_fd_sc_hd__and3b_1
XFILLER_48_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1568_ _0934_ _0937_ _0946_ _0950_ VGND VGND VPWR VPWR _0951_ sky130_fd_sc_hd__a31o_1
XFILLER_1_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_8_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_45_354 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_60_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_54_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkload14 clknet_4_15_0_sys_clk VGND VGND VPWR VPWR clkload14/Y sky130_fd_sc_hd__bufinv_16
X_1422_ _0707_ _0749_ _0797_ _0804_ VGND VGND VPWR VPWR _0805_ sky130_fd_sc_hd__nor4_1
X_1353_ net7 _0667_ VGND VGND VPWR VPWR _0736_ sky130_fd_sc_hd__nand2_1
X_1284_ net262 net6 _0666_ VGND VGND VPWR VPWR _0667_ sky130_fd_sc_hd__or3_1
XFILLER_36_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkload8 clknet_4_9_0_sys_clk VGND VGND VPWR VPWR clkload8/Y sky130_fd_sc_hd__inv_6
Xfanout234 net235 VGND VGND VPWR VPWR net234 sky130_fd_sc_hd__clkbuf_1
Xfanout201 net278 VGND VGND VPWR VPWR net201 sky130_fd_sc_hd__clkbuf_1
Xfanout256 net257 VGND VGND VPWR VPWR net256 sky130_fd_sc_hd__buf_1
Xfanout245 net246 VGND VGND VPWR VPWR net245 sky130_fd_sc_hd__clkbuf_1
Xfanout223 dynamic_ki\[2\] VGND VGND VPWR VPWR net223 sky130_fd_sc_hd__buf_1
Xfanout212 net215 VGND VGND VPWR VPWR net212 sky130_fd_sc_hd__buf_1
XFILLER_46_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_46_118 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_29_305 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_27_354 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout267 net23 VGND VGND VPWR VPWR net267 sky130_fd_sc_hd__buf_1
XFILLER_54_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_12_205 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_24_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_49_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_37_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_45_151 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_1_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_60_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1971_ _0391_ _0397_ _0400_ net179 VGND VGND VPWR VPWR _0402_ sky130_fd_sc_hd__o31a_1
X_1405_ _0776_ _0779_ _0787_ _0774_ _0765_ VGND VGND VPWR VPWR _0788_ sky130_fd_sc_hd__a32o_1
X_1267_ _0650_ _0651_ VGND VGND VPWR VPWR _0652_ sky130_fd_sc_hd__nand2_1
X_1336_ div_inst.counter\[20\] _0671_ _0716_ VGND VGND VPWR VPWR _0719_ sky130_fd_sc_hd__and3_1
X_1198_ _0590_ _0591_ net259 VGND VGND VPWR VPWR _0592_ sky130_fd_sc_hd__o21ai_1
Xinput1 div_val[0] VGND VGND VPWR VPWR net1 sky130_fd_sc_hd__buf_1
XFILLER_51_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_30_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_27_Left_88 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2170_ clknet_4_13_0_sys_clk _0101_ VGND VGND VPWR VPWR net77 sky130_fd_sc_hd__dfxtp_1
X_1121_ _0523_ _0524_ VGND VGND VPWR VPWR _0525_ sky130_fd_sc_hd__nand2b_1
X_1052_ dco_inst.accumulator\[1\] net78 VGND VGND VPWR VPWR _0466_ sky130_fd_sc_hd__and2_1
X_1954_ _0170_ net125 VGND VGND VPWR VPWR _0387_ sky130_fd_sc_hd__nand2_1
XFILLER_18_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_21_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1885_ net325 _0327_ net147 VGND VGND VPWR VPWR _0093_ sky130_fd_sc_hd__mux2_1
XFILLER_0_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1319_ net17 _0673_ VGND VGND VPWR VPWR _0702_ sky130_fd_sc_hd__nand2_1
XFILLER_21_43 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_45_403 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_15_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1670_ net237 net42 VGND VGND VPWR VPWR _0150_ sky130_fd_sc_hd__and2_1
XFILLER_23_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2084_ clknet_4_15_0_sys_clk _0025_ VGND VGND VPWR VPWR dco_inst.accumulator\[21\]
+ sky130_fd_sc_hd__dfxtp_1
X_1035_ net287 VGND VGND VPWR VPWR _0455_ sky130_fd_sc_hd__inv_2
X_1104_ dco_inst.accumulator\[9\] net184 VGND VGND VPWR VPWR _0510_ sky130_fd_sc_hd__or2_1
X_2153_ clknet_4_0_0_sys_clk _0084_ VGND VGND VPWR VPWR net89 sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_51_439 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1937_ _0366_ _0370_ VGND VGND VPWR VPWR _0372_ sky130_fd_sc_hd__and2_1
XFILLER_21_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1799_ net187 net204 _0254_ VGND VGND VPWR VPWR _0257_ sky130_fd_sc_hd__nor3_1
X_1868_ net172 _0312_ _0313_ VGND VGND VPWR VPWR _0090_ sky130_fd_sc_hd__a21o_1
XFILLER_29_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_52_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_44_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_37_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_16_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_32_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_12_168 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_4_345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_7_172 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_57_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_35_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_43_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1722_ net178 _0195_ VGND VGND VPWR VPWR _0196_ sky130_fd_sc_hd__nand2_1
X_1653_ net250 net40 VGND VGND VPWR VPWR _1019_ sky130_fd_sc_hd__or2_1
X_1584_ net226 net62 VGND VGND VPWR VPWR _0960_ sky130_fd_sc_hd__and2_1
XPHY_EDGE_ROW_9_Right_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2205_ net218 _0136_ VGND VGND VPWR VPWR div_inst.counter\[22\] sky130_fd_sc_hd__dfxtp_1
XFILLER_34_282 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2067_ clknet_4_0_0_sys_clk _0008_ VGND VGND VPWR VPWR dco_inst.accumulator\[4\]
+ sky130_fd_sc_hd__dfxtp_1
XPHY_EDGE_ROW_14_Left_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2136_ clknet_4_2_0_sys_clk _0074_ VGND VGND VPWR VPWR unlock_timer\[4\] sky130_fd_sc_hd__dfxtp_1
XFILLER_1_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_57_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_4_153 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_40_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_25_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_4_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_10_188 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1705_ net161 _0180_ VGND VGND VPWR VPWR _0181_ sky130_fd_sc_hd__nor2_1
X_1567_ _0883_ _0946_ _0949_ VGND VGND VPWR VPWR _0950_ sky130_fd_sc_hd__a21bo_1
X_1636_ net330 net152 _1002_ net172 _1003_ VGND VGND VPWR VPWR _0051_ sky130_fd_sc_hd__a221o_1
XFILLER_54_333 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1498_ net16 _0861_ _0863_ net15 VGND VGND VPWR VPWR _0881_ sky130_fd_sc_hd__o22a_1
X_2119_ clknet_4_13_0_sys_clk _0057_ VGND VGND VPWR VPWR lf_inst.integrator\[20\]
+ sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_1_134 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_22_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_13_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_38_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_1_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_54_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_9_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_13_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1421_ _0762_ _0803_ VGND VGND VPWR VPWR _0804_ sky130_fd_sc_hd__nand2_1
X_1352_ _0711_ _0713_ _0734_ VGND VGND VPWR VPWR _0735_ sky130_fd_sc_hd__o21a_1
X_1283_ net4 net264 net270 _0664_ VGND VGND VPWR VPWR _0666_ sky130_fd_sc_hd__or4_2
Xclkload9 clknet_4_10_0_sys_clk VGND VGND VPWR VPWR clkload9/Y sky130_fd_sc_hd__inv_6
Xfanout268 net21 VGND VGND VPWR VPWR net268 sky130_fd_sc_hd__buf_1
Xfanout235 net236 VGND VGND VPWR VPWR net235 sky130_fd_sc_hd__clkbuf_1
Xfanout257 net260 VGND VGND VPWR VPWR net257 sky130_fd_sc_hd__buf_1
Xfanout213 net215 VGND VGND VPWR VPWR net213 sky130_fd_sc_hd__buf_1
Xfanout224 dynamic_ki\[2\] VGND VGND VPWR VPWR net224 sky130_fd_sc_hd__dlymetal6s2s_1
Xfanout246 net251 VGND VGND VPWR VPWR net246 sky130_fd_sc_hd__clkbuf_2
X_1619_ lf_inst.integrator\[12\] net151 _0987_ net172 _0988_ VGND VGND VPWR VPWR _0049_
+ sky130_fd_sc_hd__a221o_1
XFILLER_54_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_37_350 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_29_306 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_27_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_42_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_20_250 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_1_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_18_344 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_60_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1970_ _0391_ _0397_ _0400_ VGND VGND VPWR VPWR _0401_ sky130_fd_sc_hd__o21ai_1
XFILLER_45_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_45_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_33_347 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_53_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_43_386 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1335_ div_inst.counter\[21\] _0714_ _0717_ VGND VGND VPWR VPWR _0718_ sky130_fd_sc_hd__o21ai_1
XFILLER_5_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1404_ _0780_ _0782_ _0786_ VGND VGND VPWR VPWR _0787_ sky130_fd_sc_hd__nand3_1
X_1266_ dco_inst.accumulator\[30\] net90 VGND VGND VPWR VPWR _0651_ sky130_fd_sc_hd__or2_1
XFILLER_51_100 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1197_ _0579_ _0587_ VGND VGND VPWR VPWR _0591_ sky130_fd_sc_hd__nand2_1
XFILLER_36_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_36_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xinput2 div_val[10] VGND VGND VPWR VPWR net2 sky130_fd_sc_hd__clkbuf_1
XFILLER_10_56 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_59_299 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_59_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_42_100 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_35_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_2_Left_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_2_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1051_ net299 net209 _0465_ VGND VGND VPWR VPWR _0004_ sky130_fd_sc_hd__a21oi_1
X_1120_ dco_inst.accumulator\[11\] net69 VGND VGND VPWR VPWR _0524_ sky130_fd_sc_hd__nand2_1
XFILLER_18_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1953_ _0170_ net125 VGND VGND VPWR VPWR _0386_ sky130_fd_sc_hd__nor2_1
X_1884_ net35 _0326_ net249 VGND VGND VPWR VPWR _0327_ sky130_fd_sc_hd__mux2_1
XFILLER_56_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_56_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1318_ div_inst.counter\[25\] _0700_ VGND VGND VPWR VPWR _0701_ sky130_fd_sc_hd__and2_1
X_1249_ dco_inst.accumulator\[28\] net87 VGND VGND VPWR VPWR _0636_ sky130_fd_sc_hd__or2_1
XFILLER_56_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_21_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_46_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_46_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_55_291 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_7_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_7_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2152_ clknet_4_3_0_sys_clk _0083_ VGND VGND VPWR VPWR net78 sky130_fd_sc_hd__dfxtp_1
X_2083_ clknet_4_13_0_sys_clk _0024_ VGND VGND VPWR VPWR dco_inst.accumulator\[20\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_38_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1034_ pfd_inst.ref_sync\[2\] VGND VGND VPWR VPWR _0454_ sky130_fd_sc_hd__inv_2
X_1103_ dco_inst.accumulator\[9\] net184 VGND VGND VPWR VPWR _0509_ sky130_fd_sc_hd__nor2_1
X_1936_ net310 net160 _0370_ _0371_ _0150_ VGND VGND VPWR VPWR _0100_ sky130_fd_sc_hd__a221o_1
X_1867_ net228 net63 net97 net151 VGND VGND VPWR VPWR _0313_ sky130_fd_sc_hd__a22o_1
XFILLER_21_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_21_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1798_ _0254_ _0255_ VGND VGND VPWR VPWR _0256_ sky130_fd_sc_hd__and2_1
Xinput60 initial_freq[5] VGND VGND VPWR VPWR net60 sky130_fd_sc_hd__clkbuf_1
XFILLER_29_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_29_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_12_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_32_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_7_173 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_43_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1721_ _0187_ _0194_ VGND VGND VPWR VPWR _0195_ sky130_fd_sc_hd__xnor2_1
X_1652_ net173 _1017_ VGND VGND VPWR VPWR _1018_ sky130_fd_sc_hd__nand2_1
X_1583_ net245 net328 _0959_ VGND VGND VPWR VPWR _0042_ sky130_fd_sc_hd__a21o_1
XFILLER_58_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2204_ net218 _0135_ VGND VGND VPWR VPWR div_inst.counter\[21\] sky130_fd_sc_hd__dfxtp_1
X_2135_ clknet_4_2_0_sys_clk _0073_ VGND VGND VPWR VPWR unlock_timer\[3\] sky130_fd_sc_hd__dfxtp_1
X_2066_ clknet_4_0_0_sys_clk _0007_ VGND VGND VPWR VPWR dco_inst.accumulator\[3\]
+ sky130_fd_sc_hd__dfxtp_1
X_1919_ _0351_ _0356_ VGND VGND VPWR VPWR _0357_ sky130_fd_sc_hd__xor2_1
XFILLER_1_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_4_154 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_43_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_43_42 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_40_264 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_40_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_4_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_4_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_10_189 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_48_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_31_Left_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_31_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_16_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1704_ net237 net47 VGND VGND VPWR VPWR _0180_ sky130_fd_sc_hd__and2_1
X_1566_ _0856_ _0939_ _0943_ _0948_ _0840_ VGND VGND VPWR VPWR _0949_ sky130_fd_sc_hd__o32a_1
X_1497_ _0869_ _0879_ _0866_ VGND VGND VPWR VPWR _0880_ sky130_fd_sc_hd__o21ai_1
X_1635_ net230 net38 VGND VGND VPWR VPWR _1003_ sky130_fd_sc_hd__and2_1
XFILLER_54_345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_54_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2049_ _0863_ net108 VGND VGND VPWR VPWR _0135_ sky130_fd_sc_hd__nor2_1
XFILLER_39_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2118_ clknet_4_12_0_sys_clk _0056_ VGND VGND VPWR VPWR lf_inst.integrator\[19\]
+ sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_1_135 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_60_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_57_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_54_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_54_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_45_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_13_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_9_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_9_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_23_270 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1351_ _0713_ _0715_ _0718_ VGND VGND VPWR VPWR _0734_ sky130_fd_sc_hd__or3b_1
X_1420_ _0776_ _0780_ _0782_ _0802_ VGND VGND VPWR VPWR _0803_ sky130_fd_sc_hd__and4_1
XFILLER_55_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_36_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1282_ net264 net270 _0664_ VGND VGND VPWR VPWR _0665_ sky130_fd_sc_hd__or3_1
XFILLER_51_348 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_51_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1618_ net228 net36 VGND VGND VPWR VPWR _0988_ sky130_fd_sc_hd__and2_1
Xfanout269 net20 VGND VGND VPWR VPWR net269 sky130_fd_sc_hd__dlymetal6s2s_1
Xfanout258 net259 VGND VGND VPWR VPWR net258 sky130_fd_sc_hd__dlymetal6s2s_1
Xfanout236 net239 VGND VGND VPWR VPWR net236 sky130_fd_sc_hd__buf_1
Xfanout214 net215 VGND VGND VPWR VPWR net214 sky130_fd_sc_hd__clkbuf_1
X_1549_ _0929_ _0931_ _0895_ VGND VGND VPWR VPWR _0932_ sky130_fd_sc_hd__o21a_1
XTAP_TAPCELL_ROW_29_307 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout203 lf_inst.error_in\[0\] VGND VGND VPWR VPWR net203 sky130_fd_sc_hd__buf_1
Xfanout225 net226 VGND VGND VPWR VPWR net225 sky130_fd_sc_hd__buf_1
Xfanout247 net251 VGND VGND VPWR VPWR net247 sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_37_351 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_10_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_20_251 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_1_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_60_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_43_387 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1265_ dco_inst.accumulator\[30\] net90 VGND VGND VPWR VPWR _0650_ sky130_fd_sc_hd__nand2_1
XFILLER_46_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1334_ _0671_ _0716_ div_inst.counter\[20\] VGND VGND VPWR VPWR _0717_ sky130_fd_sc_hd__a21o_1
X_1403_ net121 _0781_ _0784_ _0785_ VGND VGND VPWR VPWR _0786_ sky130_fd_sc_hd__a22o_1
XPHY_EDGE_ROW_18_Right_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1196_ _0588_ _0589_ VGND VGND VPWR VPWR _0590_ sky130_fd_sc_hd__and2b_1
XFILLER_36_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_36_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_34_332 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_27_Right_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xinput3 div_val[11] VGND VGND VPWR VPWR net3 sky130_fd_sc_hd__clkbuf_1
XFILLER_24_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_51_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_36_Right_36 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_10_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_10_68 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_59_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_45_Right_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_42_112 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_35_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_30_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_15_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_54_Right_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_40_368 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1050_ dco_inst.accumulator\[0\] net209 net242 VGND VGND VPWR VPWR _0465_ sky130_fd_sc_hd__o21ai_1
XFILLER_18_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_18_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_18_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1952_ _0383_ _0384_ _0385_ VGND VGND VPWR VPWR _0102_ sky130_fd_sc_hd__o21ai_1
XFILLER_33_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1883_ _0324_ _0325_ VGND VGND VPWR VPWR _0326_ sky130_fd_sc_hd__xnor2_1
XFILLER_21_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1248_ net258 _0634_ _0635_ VGND VGND VPWR VPWR _0031_ sky130_fd_sc_hd__and3_1
X_1317_ net274 net112 VGND VGND VPWR VPWR _0700_ sky130_fd_sc_hd__xor2_1
X_1179_ _0573_ _0574_ VGND VGND VPWR VPWR _0575_ sky130_fd_sc_hd__nand2b_1
XFILLER_12_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_12_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_24_101 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_21_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_46_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_7_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_15_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_7_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_38_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_38_215 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2082_ clknet_4_13_0_sys_clk _0023_ VGND VGND VPWR VPWR dco_inst.accumulator\[19\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_30_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2151_ clknet_4_6_0_sys_clk _0082_ VGND VGND VPWR VPWR lf_inst.zero_error_count\[4\]
+ sky130_fd_sc_hd__dfxtp_1
X_1102_ _0508_ _0507_ VGND VGND VPWR VPWR _0012_ sky130_fd_sc_hd__and2b_1
XFILLER_46_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1033_ net254 VGND VGND VPWR VPWR _0453_ sky130_fd_sc_hd__inv_2
Xinput50 initial_freq[25] VGND VGND VPWR VPWR net50 sky130_fd_sc_hd__clkbuf_1
X_1935_ _0367_ _0368_ _0369_ net169 VGND VGND VPWR VPWR _0371_ sky130_fd_sc_hd__a31oi_1
X_1797_ net185 net203 net205 VGND VGND VPWR VPWR _0255_ sky130_fd_sc_hd__o21ai_1
Xinput61 initial_freq[6] VGND VGND VPWR VPWR net61 sky130_fd_sc_hd__clkbuf_1
X_1866_ _0310_ _0311_ VGND VGND VPWR VPWR _0312_ sky130_fd_sc_hd__nor2_1
XFILLER_21_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_52_284 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_52_240 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_50_430 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_0_Right_0 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_7_174 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_28_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_44_Left_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1720_ _0163_ _0193_ VGND VGND VPWR VPWR _0194_ sky130_fd_sc_hd__nor2_1
X_1651_ _1015_ _1016_ VGND VGND VPWR VPWR _1017_ sky130_fd_sc_hd__nand2_1
XFILLER_11_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1582_ net225 net61 VGND VGND VPWR VPWR _0959_ sky130_fd_sc_hd__and2_1
XPHY_EDGE_ROW_53_Left_114 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2203_ net217 _0134_ VGND VGND VPWR VPWR div_inst.counter\[20\] sky130_fd_sc_hd__dfxtp_1
X_2134_ clknet_4_2_0_sys_clk _0072_ VGND VGND VPWR VPWR unlock_timer\[2\] sky130_fd_sc_hd__dfxtp_1
X_2065_ clknet_4_0_0_sys_clk _0006_ VGND VGND VPWR VPWR dco_inst.accumulator\[2\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_19_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_34_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1918_ _0352_ _0355_ VGND VGND VPWR VPWR _0356_ sky130_fd_sc_hd__and2_1
X_1849_ lf_inst.integrator\[4\] lf_inst.integrator\[5\] net138 VGND VGND VPWR VPWR
+ _0297_ sky130_fd_sc_hd__o21ai_1
XTAP_TAPCELL_ROW_4_155 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_27_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_43_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_4_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1703_ _0178_ VGND VGND VPWR VPWR _0179_ sky130_fd_sc_hd__inv_2
X_1634_ _0997_ _1001_ VGND VGND VPWR VPWR _1002_ sky130_fd_sc_hd__xnor2_2
X_1565_ _0843_ _0942_ _0940_ VGND VGND VPWR VPWR _0948_ sky130_fd_sc_hd__a21oi_1
X_1496_ _0875_ _0876_ _0877_ _0871_ VGND VGND VPWR VPWR _0879_ sky130_fd_sc_hd__o31a_1
XFILLER_54_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2048_ _0865_ net106 VGND VGND VPWR VPWR _0134_ sky130_fd_sc_hd__nor2_1
X_2117_ clknet_4_12_0_sys_clk _0055_ VGND VGND VPWR VPWR lf_inst.integrator\[18\]
+ sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_1_136 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_13_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_45_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_60_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_60_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_9_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_13_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_23_271 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1350_ _0712_ _0732_ _0720_ _0722_ VGND VGND VPWR VPWR _0733_ sky130_fd_sc_hd__or4b_1
X_1281_ net263 net32 net31 _0662_ VGND VGND VPWR VPWR _0664_ sky130_fd_sc_hd__or4_2
Xfanout204 lf_inst.error_in\[0\] VGND VGND VPWR VPWR net204 sky130_fd_sc_hd__clkbuf_1
X_1617_ net280 _0986_ VGND VGND VPWR VPWR _0987_ sky130_fd_sc_hd__xnor2_2
X_1479_ net17 _0859_ _0861_ net16 VGND VGND VPWR VPWR _0862_ sky130_fd_sc_hd__a22o_1
Xfanout215 net222 VGND VGND VPWR VPWR net215 sky130_fd_sc_hd__buf_1
Xfanout259 net260 VGND VGND VPWR VPWR net259 sky130_fd_sc_hd__dlymetal6s2s_1
Xfanout237 net238 VGND VGND VPWR VPWR net237 sky130_fd_sc_hd__buf_1
X_1548_ _0930_ VGND VGND VPWR VPWR _0931_ sky130_fd_sc_hd__inv_2
XFILLER_27_324 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout226 net227 VGND VGND VPWR VPWR net226 sky130_fd_sc_hd__dlymetal6s2s_1
Xfanout248 net250 VGND VGND VPWR VPWR net248 sky130_fd_sc_hd__dlymetal6s2s_1
XTAP_TAPCELL_ROW_37_352 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_40_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_6_228 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_20_252 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_6_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_60_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_1_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_43_388 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1402_ div_inst.counter\[1\] _0659_ _0783_ net1 net124 VGND VGND VPWR VPWR _0785_
+ sky130_fd_sc_hd__a32o_1
X_1264_ _0648_ _0649_ VGND VGND VPWR VPWR _0033_ sky130_fd_sc_hd__nor2_1
X_1333_ net277 _0670_ net13 VGND VGND VPWR VPWR _0716_ sky130_fd_sc_hd__o21ai_1
XFILLER_39_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xinput4 div_val[12] VGND VGND VPWR VPWR net4 sky130_fd_sc_hd__buf_1
Xclkbuf_4_2_0_sys_clk clknet_0_sys_clk VGND VGND VPWR VPWR clknet_4_2_0_sys_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_51_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1195_ dco_inst.accumulator\[21\] net80 VGND VGND VPWR VPWR _0589_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_34_333 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_51_10 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_50_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_42_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_42_124 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_40_369 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_2_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_2_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_33_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1951_ net302 net163 _0167_ VGND VGND VPWR VPWR _0385_ sky130_fd_sc_hd__a21oi_1
XTAP_TAPCELL_ROW_31_314 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1882_ _0975_ net135 _0322_ VGND VGND VPWR VPWR _0325_ sky130_fd_sc_hd__o21ba_1
X_1247_ _0623_ _0630_ _0631_ _0632_ VGND VGND VPWR VPWR _0635_ sky130_fd_sc_hd__a211o_1
X_1316_ div_inst.counter\[26\] _0675_ _0695_ _0694_ VGND VGND VPWR VPWR _0699_ sky130_fd_sc_hd__a31o_1
X_1178_ dco_inst.accumulator\[19\] net77 VGND VGND VPWR VPWR _0574_ sky130_fd_sc_hd__nand2_1
XFILLER_24_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_53_450 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_47_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_15_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_15_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_7_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_11_352 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_38_227 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2081_ clknet_4_13_0_sys_clk _0022_ VGND VGND VPWR VPWR dco_inst.accumulator\[18\]
+ sky130_fd_sc_hd__dfxtp_1
X_2150_ clknet_4_2_0_sys_clk _0081_ VGND VGND VPWR VPWR lf_inst.zero_error_count\[3\]
+ sky130_fd_sc_hd__dfxtp_1
X_1032_ unlock_timer\[5\] VGND VGND VPWR VPWR _0452_ sky130_fd_sc_hd__inv_2
X_1101_ _0498_ _0502_ _0506_ net228 VGND VGND VPWR VPWR _0508_ sky130_fd_sc_hd__a31o_1
X_1934_ _0368_ _0369_ _0367_ VGND VGND VPWR VPWR _0370_ sky130_fd_sc_hd__a21o_1
Xinput51 initial_freq[26] VGND VGND VPWR VPWR net51 sky130_fd_sc_hd__clkbuf_1
X_1796_ net205 _0253_ VGND VGND VPWR VPWR _0254_ sky130_fd_sc_hd__nand2_1
Xinput40 initial_freq[16] VGND VGND VPWR VPWR net40 sky130_fd_sc_hd__clkbuf_1
Xinput62 initial_freq[7] VGND VGND VPWR VPWR net62 sky130_fd_sc_hd__clkbuf_1
X_1865_ _0308_ _0306_ _0309_ VGND VGND VPWR VPWR _0311_ sky130_fd_sc_hd__a21oi_4
XFILLER_29_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_50_431 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_8_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_12_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_57_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_7_175 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1650_ _1010_ _1011_ _1014_ VGND VGND VPWR VPWR _1016_ sky130_fd_sc_hd__nand3_1
X_1581_ net242 lf_inst.integrator\[5\] _0958_ VGND VGND VPWR VPWR _0041_ sky130_fd_sc_hd__a21o_1
X_2202_ net217 _0133_ VGND VGND VPWR VPWR div_inst.counter\[19\] sky130_fd_sc_hd__dfxtp_1
X_2064_ clknet_4_0_0_sys_clk _0005_ VGND VGND VPWR VPWR dco_inst.accumulator\[1\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_19_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2133_ clknet_4_2_0_sys_clk _0071_ VGND VGND VPWR VPWR unlock_timer\[1\] sky130_fd_sc_hd__dfxtp_1
X_1917_ net146 _1006_ _0354_ _0353_ VGND VGND VPWR VPWR _0355_ sky130_fd_sc_hd__a211oi_2
XFILLER_1_318 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1848_ lf_inst.integrator\[6\] net137 VGND VGND VPWR VPWR _0296_ sky130_fd_sc_hd__xnor2_1
X_1779_ net327 _0241_ _0243_ VGND VGND VPWR VPWR _0071_ sky130_fd_sc_hd__o21a_1
XTAP_TAPCELL_ROW_4_156 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_25_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_4_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_18_236 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_31_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1702_ _0175_ _0177_ VGND VGND VPWR VPWR _0178_ sky130_fd_sc_hd__xnor2_1
X_1564_ _0937_ _0946_ VGND VGND VPWR VPWR _0947_ sky130_fd_sc_hd__nand2_1
X_1633_ _0979_ _0985_ _0998_ _1000_ VGND VGND VPWR VPWR _1001_ sky130_fd_sc_hd__o31a_1
XFILLER_39_344 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_39_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1495_ _0876_ _0877_ VGND VGND VPWR VPWR _0878_ sky130_fd_sc_hd__nor2_1
XPHY_EDGE_ROW_18_Left_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2047_ _0868_ net106 VGND VGND VPWR VPWR _0133_ sky130_fd_sc_hd__nor2_1
X_2116_ clknet_4_12_0_sys_clk _0054_ VGND VGND VPWR VPWR lf_inst.integrator\[17\]
+ sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_1_137 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_13_25 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_13_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_1_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_57_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_9_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_48_8 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_48_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1280_ net263 _0662_ VGND VGND VPWR VPWR _0663_ sky130_fd_sc_hd__nor2_1
XFILLER_51_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xfanout216 net217 VGND VGND VPWR VPWR net216 sky130_fd_sc_hd__buf_1
Xfanout238 net239 VGND VGND VPWR VPWR net238 sky130_fd_sc_hd__clkbuf_2
X_1547_ net4 _0894_ _0898_ net264 VGND VGND VPWR VPWR _0930_ sky130_fd_sc_hd__a22oi_2
Xfanout205 lf_inst.sample_en VGND VGND VPWR VPWR net205 sky130_fd_sc_hd__buf_1
Xfanout227 net232 VGND VGND VPWR VPWR net227 sky130_fd_sc_hd__clkbuf_2
XFILLER_5_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1616_ _0979_ _0985_ VGND VGND VPWR VPWR _0986_ sky130_fd_sc_hd__nor2_1
XFILLER_54_100 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1478_ net117 _0827_ VGND VGND VPWR VPWR _0861_ sky130_fd_sc_hd__xnor2_1
XFILLER_39_185 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout249 net251 VGND VGND VPWR VPWR net249 sky130_fd_sc_hd__clkbuf_2
XFILLER_42_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_37_353 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_10_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_24_13 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_24_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_10_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_20_253 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_33_317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_33_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_1_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_18_314 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_60_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_60_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_43_389 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1401_ _0659_ _0783_ net122 VGND VGND VPWR VPWR _0784_ sky130_fd_sc_hd__a21o_1
X_1263_ _0637_ _0642_ _0647_ net234 VGND VGND VPWR VPWR _0649_ sky130_fd_sc_hd__a31o_1
X_1332_ div_inst.counter\[22\] _0710_ _0714_ div_inst.counter\[21\] VGND VGND VPWR
+ VPWR _0715_ sky130_fd_sc_hd__a22o_1
X_1194_ dco_inst.accumulator\[21\] net80 VGND VGND VPWR VPWR _0588_ sky130_fd_sc_hd__nor2_1
Xinput5 div_val[13] VGND VGND VPWR VPWR net5 sky130_fd_sc_hd__buf_1
Xclkbuf_4_6_0_sys_clk clknet_0_sys_clk VGND VGND VPWR VPWR clknet_4_6_0_sys_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_51_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_34_334 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_59_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_42_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_51_88 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_51_22 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1950_ _0380_ _0381_ _0382_ net169 VGND VGND VPWR VPWR _0384_ sky130_fd_sc_hd__a31o_1
XFILLER_33_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_33_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_31_315 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1881_ _0982_ net139 VGND VGND VPWR VPWR _0324_ sky130_fd_sc_hd__xnor2_1
X_1315_ div_inst.counter\[27\] _0693_ _0696_ VGND VGND VPWR VPWR _0698_ sky130_fd_sc_hd__o21bai_1
XFILLER_51_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1246_ _0631_ _0632_ _0623_ _0630_ VGND VGND VPWR VPWR _0634_ sky130_fd_sc_hd__o211ai_1
X_1177_ dco_inst.accumulator\[19\] net77 VGND VGND VPWR VPWR _0573_ sky130_fd_sc_hd__nor2_1
XFILLER_24_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_12_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_46_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_6_Left_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_53_451 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_46_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_15_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_30_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_7_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_7_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_23_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_11_80 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_23_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_38_239 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2080_ clknet_4_6_0_sys_clk _0021_ VGND VGND VPWR VPWR dco_inst.accumulator\[17\]
+ sky130_fd_sc_hd__dfxtp_1
X_1031_ lf_inst.zero_error_count\[3\] VGND VGND VPWR VPWR _0451_ sky130_fd_sc_hd__inv_2
X_1100_ _0498_ _0502_ _0506_ VGND VGND VPWR VPWR _0507_ sky130_fd_sc_hd__a21o_1
XFILLER_16_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1933_ net143 _1017_ _0359_ VGND VGND VPWR VPWR _0369_ sky130_fd_sc_hd__o21ba_1
XFILLER_21_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xinput52 initial_freq[27] VGND VGND VPWR VPWR net52 sky130_fd_sc_hd__clkbuf_1
X_1795_ lf_inst.zero_error_count\[3\] lf_inst.zero_error_count\[2\] lf_inst.zero_error_count\[4\]
+ VGND VGND VPWR VPWR _0253_ sky130_fd_sc_hd__o21ai_1
Xinput41 initial_freq[17] VGND VGND VPWR VPWR net41 sky130_fd_sc_hd__clkbuf_1
Xinput63 initial_freq[8] VGND VGND VPWR VPWR net63 sky130_fd_sc_hd__clkbuf_1
X_1864_ _0306_ _0308_ _0309_ VGND VGND VPWR VPWR _0310_ sky130_fd_sc_hd__and3_1
Xinput30 div_val[7] VGND VGND VPWR VPWR net30 sky130_fd_sc_hd__clkbuf_1
X_1229_ _0617_ _0618_ VGND VGND VPWR VPWR _0619_ sky130_fd_sc_hd__nand2_1
XFILLER_52_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_37_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_50_432 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_12_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_43_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1580_ net225 net60 VGND VGND VPWR VPWR _0958_ sky130_fd_sc_hd__and2_1
XFILLER_7_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_11_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2201_ net213 _0132_ VGND VGND VPWR VPWR div_inst.counter\[18\] sky130_fd_sc_hd__dfxtp_1
X_2132_ clknet_4_2_0_sys_clk _0070_ VGND VGND VPWR VPWR unlock_timer\[0\] sky130_fd_sc_hd__dfxtp_1
XFILLER_34_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2063_ clknet_4_0_0_sys_clk net300 VGND VGND VPWR VPWR dco_inst.accumulator\[0\]
+ sky130_fd_sc_hd__dfxtp_1
X_1847_ net335 net148 _0294_ _0295_ _0958_ VGND VGND VPWR VPWR _0087_ sky130_fd_sc_hd__a221o_1
X_1916_ net279 _1002_ _0331_ VGND VGND VPWR VPWR _0354_ sky130_fd_sc_hd__a21o_1
X_1778_ unlock_timer\[1\] _0241_ net141 VGND VGND VPWR VPWR _0243_ sky130_fd_sc_hd__a21boi_1
XFILLER_27_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_4_157 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_43_67 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_27_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_4_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_9_Left_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_18_237 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1701_ _0161_ _0164_ _0168_ _0176_ VGND VGND VPWR VPWR _0177_ sky130_fd_sc_hd__a31o_1
XFILLER_31_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1563_ _0943_ _0945_ VGND VGND VPWR VPWR _0946_ sky130_fd_sc_hd__nor2_1
X_1494_ net10 _0873_ VGND VGND VPWR VPWR _0877_ sky130_fd_sc_hd__nor2_1
X_1632_ _0999_ VGND VGND VPWR VPWR _1000_ sky130_fd_sc_hd__inv_2
X_2115_ clknet_4_6_0_sys_clk _0053_ VGND VGND VPWR VPWR lf_inst.integrator\[16\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_1_138 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2046_ _0870_ net106 VGND VGND VPWR VPWR _0132_ sky130_fd_sc_hd__nor2_1
XFILLER_13_37 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_54_33 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_45_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_35_Left_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_9_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_13_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_13_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_15_218 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_48_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_36_348 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_8_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1477_ net17 _0859_ VGND VGND VPWR VPWR _0860_ sky130_fd_sc_hd__or2_1
Xfanout217 net221 VGND VGND VPWR VPWR net217 sky130_fd_sc_hd__buf_1
Xfanout239 net240 VGND VGND VPWR VPWR net239 sky130_fd_sc_hd__buf_1
Xfanout206 lf_inst.sample_en VGND VGND VPWR VPWR net206 sky130_fd_sc_hd__buf_1
X_1546_ net270 _0897_ _0898_ net264 _0928_ VGND VGND VPWR VPWR _0929_ sky130_fd_sc_hd__o221a_1
XFILLER_5_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout228 net230 VGND VGND VPWR VPWR net228 sky130_fd_sc_hd__clkbuf_2
X_1615_ _0962_ _0973_ _0980_ _0972_ VGND VGND VPWR VPWR _0985_ sky130_fd_sc_hd__a211oi_2
XPHY_EDGE_ROW_59_Left_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_54_112 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_39_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_37_354 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_54_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2029_ _0908_ net101 VGND VGND VPWR VPWR _0115_ sky130_fd_sc_hd__nor2_1
XFILLER_24_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_24_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_49_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_49_33 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_60_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_45_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_33_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1331_ net14 _0671_ VGND VGND VPWR VPWR _0714_ sky130_fd_sc_hd__xor2_1
X_1400_ net1 net12 VGND VGND VPWR VPWR _0783_ sky130_fd_sc_hd__nand2_1
X_1262_ _0637_ _0642_ _0647_ VGND VGND VPWR VPWR _0648_ sky130_fd_sc_hd__a21oi_1
X_1193_ net259 _0586_ _0587_ VGND VGND VPWR VPWR _0024_ sky130_fd_sc_hd__and3_1
XFILLER_36_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xinput6 div_val[14] VGND VGND VPWR VPWR net6 sky130_fd_sc_hd__clkbuf_1
XFILLER_24_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_51_126 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_34_335 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_59_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_27_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1529_ net265 _0903_ _0906_ VGND VGND VPWR VPWR _0912_ sky130_fd_sc_hd__o21a_1
XFILLER_19_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_35_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_35_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_27_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_14_Right_14 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_23_Right_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_58_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_48_416 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_33_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_32_Right_32 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_31_316 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1880_ net324 net151 _0321_ _0323_ _0977_ VGND VGND VPWR VPWR _0092_ sky130_fd_sc_hd__a221o_1
XFILLER_18_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_56_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1314_ div_inst.counter\[27\] _0693_ _0696_ VGND VGND VPWR VPWR _0697_ sky130_fd_sc_hd__o21ba_1
XPHY_EDGE_ROW_41_Right_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_22_Left_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1245_ dco_inst.accumulator\[27\] net86 VGND VGND VPWR VPWR _0633_ sky130_fd_sc_hd__nand2_1
XPHY_EDGE_ROW_50_Right_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_49_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1176_ _0567_ _0570_ _0572_ VGND VGND VPWR VPWR _0022_ sky130_fd_sc_hd__a21oi_1
XFILLER_2_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_24_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_46_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_15_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_7_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_11_92 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xinput20 div_val[27] VGND VGND VPWR VPWR net20 sky130_fd_sc_hd__clkbuf_1
X_1932_ _0355_ _0352_ _0359_ _0360_ _0351_ VGND VGND VPWR VPWR _0368_ sky130_fd_sc_hd__a2111o_1
X_1863_ lf_inst.integrator\[8\] net139 VGND VGND VPWR VPWR _0309_ sky130_fd_sc_hd__xnor2_1
Xinput31 div_val[8] VGND VGND VPWR VPWR net31 sky130_fd_sc_hd__buf_1
Xinput53 initial_freq[28] VGND VGND VPWR VPWR net53 sky130_fd_sc_hd__clkbuf_1
X_1794_ _0455_ _0252_ net236 VGND VGND VPWR VPWR _0077_ sky130_fd_sc_hd__a21oi_1
Xinput42 initial_freq[18] VGND VGND VPWR VPWR net42 sky130_fd_sc_hd__clkbuf_1
Xinput64 initial_freq[9] VGND VGND VPWR VPWR net64 sky130_fd_sc_hd__clkbuf_1
X_1228_ dco_inst.accumulator\[25\] net84 VGND VGND VPWR VPWR _0618_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_50_433 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1159_ _0544_ _0556_ _0557_ VGND VGND VPWR VPWR _0558_ sky130_fd_sc_hd__o21a_1
XFILLER_4_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_28_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_7_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2200_ net216 _0131_ VGND VGND VPWR VPWR div_inst.counter\[17\] sky130_fd_sc_hd__dfxtp_1
X_2131_ clknet_4_3_0_sys_clk _0069_ VGND VGND VPWR VPWR dynamic_kp\[2\] sky130_fd_sc_hd__dfxtp_1
X_2062_ clknet_4_3_0_sys_clk _0003_ VGND VGND VPWR VPWR dynamic_ki\[2\] sky130_fd_sc_hd__dfxtp_1
X_1846_ _0287_ _0291_ _0293_ net166 VGND VGND VPWR VPWR _0295_ sky130_fd_sc_hd__a31oi_1
X_1915_ _1009_ _0311_ _0324_ _0329_ VGND VGND VPWR VPWR _0353_ sky130_fd_sc_hd__and4b_1
X_1777_ _0241_ _0242_ VGND VGND VPWR VPWR _0070_ sky130_fd_sc_hd__nor2_1
XPHY_EDGE_ROW_4_Right_4 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_57_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_40_Left_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_27_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_25_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_43_79 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_43_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_43_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_25_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_4_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_31_202 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_16_276 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_18_238 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1700_ lf_inst.integrator\[20\] lf_inst.integrator\[21\] net198 VGND VGND VPWR VPWR
+ _0176_ sky130_fd_sc_hd__o21a_1
X_1631_ lf_inst.integrator\[12\] net144 _0989_ lf_inst.integrator\[13\] VGND VGND
+ VPWR VPWR _0999_ sky130_fd_sc_hd__a22o_1
X_1562_ _0852_ _0854_ _0857_ _0944_ VGND VGND VPWR VPWR _0945_ sky130_fd_sc_hd__or4_1
X_1493_ net277 _0870_ VGND VGND VPWR VPWR _0876_ sky130_fd_sc_hd__nor2_1
X_2045_ _0873_ net107 VGND VGND VPWR VPWR _0131_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_1_139 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2114_ clknet_4_7_0_sys_clk _0052_ VGND VGND VPWR VPWR lf_inst.integrator\[15\] sky130_fd_sc_hd__dfxtp_1
X_1829_ lf_inst.integrator\[3\] net136 VGND VGND VPWR VPWR _0280_ sky130_fd_sc_hd__nand2_1
XFILLER_13_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_57_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_54_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_15_219 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_9_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_13_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_36_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_8_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1614_ net145 lf_inst.integrator\[12\] VGND VGND VPWR VPWR _0984_ sky130_fd_sc_hd__xnor2_4
Xfanout218 net220 VGND VGND VPWR VPWR net218 sky130_fd_sc_hd__clkbuf_1
X_1476_ _0829_ _0858_ VGND VGND VPWR VPWR _0859_ sky130_fd_sc_hd__or2_1
X_1545_ _0901_ _0927_ _0900_ VGND VGND VPWR VPWR _0928_ sky130_fd_sc_hd__o21ai_1
Xfanout229 net230 VGND VGND VPWR VPWR net229 sky130_fd_sc_hd__clkbuf_1
Xfanout207 dynamic_kp\[2\] VGND VGND VPWR VPWR net207 sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_54_168 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_54_124 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_37_355 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2028_ net123 net101 VGND VGND VPWR VPWR _0114_ sky130_fd_sc_hd__nor2_1
XFILLER_24_37 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_28_300 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_60_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_5_264 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1261_ _0644_ _0646_ VGND VGND VPWR VPWR _0647_ sky130_fd_sc_hd__nand2_1
X_1330_ div_inst.counter\[23\] _0673_ _0708_ VGND VGND VPWR VPWR _0713_ sky130_fd_sc_hd__and3_1
X_1192_ _0580_ _0585_ VGND VGND VPWR VPWR _0587_ sky130_fd_sc_hd__nand2_1
Xinput7 div_val[15] VGND VGND VPWR VPWR net7 sky130_fd_sc_hd__buf_1
XFILLER_24_319 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_51_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_42_380 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_34_336 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_59_238 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1459_ _0834_ _0841_ VGND VGND VPWR VPWR _0842_ sky130_fd_sc_hd__or2_1
XFILLER_27_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1528_ _0906_ _0907_ _0909_ _0910_ VGND VGND VPWR VPWR _0911_ sky130_fd_sc_hd__and4b_1
XFILLER_19_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_50_171 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_4_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_58_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_48_417 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_41_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_33_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_31_317 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1244_ dco_inst.accumulator\[27\] net86 VGND VGND VPWR VPWR _0632_ sky130_fd_sc_hd__and2_1
X_1313_ _0675_ _0695_ div_inst.counter\[26\] VGND VGND VPWR VPWR _0696_ sky130_fd_sc_hd__a21oi_1
X_1175_ net259 _0571_ VGND VGND VPWR VPWR _0572_ sky130_fd_sc_hd__nand2_1
XFILLER_24_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_11_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_15_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_7_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xinput54 initial_freq[29] VGND VGND VPWR VPWR net54 sky130_fd_sc_hd__clkbuf_1
Xinput21 div_val[28] VGND VGND VPWR VPWR net21 sky130_fd_sc_hd__clkbuf_1
X_1793_ pfd_inst.state\[0\] pfd_inst.state\[2\] net195 VGND VGND VPWR VPWR _0252_
+ sky130_fd_sc_hd__or3b_1
Xinput10 div_val[18] VGND VGND VPWR VPWR net10 sky130_fd_sc_hd__buf_1
Xinput43 initial_freq[19] VGND VGND VPWR VPWR net43 sky130_fd_sc_hd__clkbuf_1
X_1931_ _0148_ net127 VGND VGND VPWR VPWR _0367_ sky130_fd_sc_hd__xnor2_1
X_1862_ _0307_ VGND VGND VPWR VPWR _0308_ sky130_fd_sc_hd__inv_2
Xinput32 div_val[9] VGND VGND VPWR VPWR net32 sky130_fd_sc_hd__buf_1
Xinput65 ref_clk VGND VGND VPWR VPWR net65 sky130_fd_sc_hd__clkbuf_1
X_1227_ dco_inst.accumulator\[25\] net84 VGND VGND VPWR VPWR _0617_ sky130_fd_sc_hd__or2_1
X_1158_ _0541_ _0549_ _0548_ VGND VGND VPWR VPWR _0557_ sky130_fd_sc_hd__o21ba_1
XFILLER_32_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1089_ _0496_ _0497_ VGND VGND VPWR VPWR _0010_ sky130_fd_sc_hd__nor2_1
XFILLER_16_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_20_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_57_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_43_200 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2130_ clknet_4_10_0_sys_clk _0068_ VGND VGND VPWR VPWR lf_inst.integrator\[31\]
+ sky130_fd_sc_hd__dfxtp_1
X_2061_ net99 _0450_ _0266_ VGND VGND VPWR VPWR _0146_ sky130_fd_sc_hd__o21a_1
XFILLER_21_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1914_ net146 _1006_ _0341_ _0342_ VGND VGND VPWR VPWR _0352_ sky130_fd_sc_hd__o211ai_1
X_1845_ _0287_ _0291_ _0293_ VGND VGND VPWR VPWR _0294_ sky130_fd_sc_hd__a21o_1
XFILLER_8_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1776_ _0452_ net319 _0240_ VGND VGND VPWR VPWR _0242_ sky130_fd_sc_hd__o21ai_1
XFILLER_25_255 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_16_288 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_17_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_18_239 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_31_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1630_ _0984_ _0990_ VGND VGND VPWR VPWR _0998_ sky130_fd_sc_hd__or2_1
X_1561_ _0848_ _0849_ _0939_ VGND VGND VPWR VPWR _0944_ sky130_fd_sc_hd__or3_1
XFILLER_39_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1492_ net10 _0873_ _0874_ net9 VGND VGND VPWR VPWR _0875_ sky130_fd_sc_hd__a22oi_1
X_2044_ _0874_ net106 VGND VGND VPWR VPWR _0130_ sky130_fd_sc_hd__nor2_1
X_2113_ clknet_4_7_0_sys_clk _0051_ VGND VGND VPWR VPWR lf_inst.integrator\[14\] sky130_fd_sc_hd__dfxtp_1
X_1759_ net233 net54 VGND VGND VPWR VPWR _0228_ sky130_fd_sc_hd__and2_1
X_1828_ net226 net55 net323 net148 _0279_ VGND VGND VPWR VPWR _0084_ sky130_fd_sc_hd__a221o_1
XFILLER_57_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_38_47 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_60_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_13_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_48_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_51_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_48_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_5_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1613_ net226 net35 net149 net294 _0983_ VGND VGND VPWR VPWR _0048_ sky130_fd_sc_hd__a221o_1
X_1544_ _0917_ _0923_ _0925_ _0926_ VGND VGND VPWR VPWR _0927_ sky130_fd_sc_hd__a22oi_1
Xfanout219 net220 VGND VGND VPWR VPWR net219 sky130_fd_sc_hd__clkbuf_1
X_1475_ net117 _0827_ div_inst.counter\[23\] VGND VGND VPWR VPWR _0858_ sky130_fd_sc_hd__a21oi_1
Xfanout208 dynamic_kp\[2\] VGND VGND VPWR VPWR net208 sky130_fd_sc_hd__buf_1
XFILLER_54_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2027_ net252 _0800_ _0806_ VGND VGND VPWR VPWR _0449_ sky130_fd_sc_hd__nand3_1
XFILLER_42_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_24_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_40_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_49_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_45_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_28_301 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_5_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1260_ dco_inst.accumulator\[29\] net88 VGND VGND VPWR VPWR _0646_ sky130_fd_sc_hd__nand2_1
X_1191_ _0580_ _0585_ VGND VGND VPWR VPWR _0586_ sky130_fd_sc_hd__or2_1
Xinput8 div_val[16] VGND VGND VPWR VPWR net8 sky130_fd_sc_hd__buf_1
XFILLER_36_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_34_337 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_24_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_42_381 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_32_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_10_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1527_ net267 _0908_ VGND VGND VPWR VPWR _0910_ sky130_fd_sc_hd__or2_1
X_1458_ div_inst.counter\[28\] _0833_ div_inst.counter\[29\] VGND VGND VPWR VPWR _0841_
+ sky130_fd_sc_hd__a21oi_1
XFILLER_27_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1389_ div_inst.counter\[5\] _0769_ _0771_ net120 VGND VGND VPWR VPWR _0772_ sky130_fd_sc_hd__o22a_1
XFILLER_35_26 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_27_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_51_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_51_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_2_268 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_48_418 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_33_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkbuf_4_12_0_sys_clk clknet_0_sys_clk VGND VGND VPWR VPWR clknet_4_12_0_sys_clk
+ sky130_fd_sc_hd__clkbuf_8
XTAP_TAPCELL_ROW_31_318 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_25_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_41_80 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1243_ dco_inst.accumulator\[27\] net86 VGND VGND VPWR VPWR _0631_ sky130_fd_sc_hd__nor2_1
X_1312_ net274 _0674_ net272 VGND VGND VPWR VPWR _0695_ sky130_fd_sc_hd__o21ai_1
XFILLER_49_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1174_ _0567_ _0570_ VGND VGND VPWR VPWR _0571_ sky130_fd_sc_hd__or2_1
XFILLER_2_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_46_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_30_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_23_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_7_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1930_ _0148_ net127 VGND VGND VPWR VPWR _0366_ sky130_fd_sc_hd__or2_1
Xinput22 div_val[29] VGND VGND VPWR VPWR net22 sky130_fd_sc_hd__buf_1
Xinput11 div_val[19] VGND VGND VPWR VPWR net11 sky130_fd_sc_hd__buf_1
X_1792_ net287 net312 _0251_ net254 VGND VGND VPWR VPWR _0076_ sky130_fd_sc_hd__o31a_1
Xinput66 rst_n VGND VGND VPWR VPWR net66 sky130_fd_sc_hd__clkbuf_1
Xinput33 initial_freq[0] VGND VGND VPWR VPWR net33 sky130_fd_sc_hd__clkbuf_1
Xinput55 initial_freq[2] VGND VGND VPWR VPWR net55 sky130_fd_sc_hd__buf_1
Xinput44 initial_freq[1] VGND VGND VPWR VPWR net44 sky130_fd_sc_hd__clkbuf_1
X_1861_ lf_inst.integrator\[4\] lf_inst.integrator\[5\] lf_inst.integrator\[6\] lf_inst.integrator\[7\]
+ net137 VGND VGND VPWR VPWR _0307_ sky130_fd_sc_hd__o41a_1
X_1226_ net258 _0615_ _0616_ VGND VGND VPWR VPWR _0028_ sky130_fd_sc_hd__and3_1
XFILLER_52_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1157_ _0545_ _0549_ _0555_ VGND VGND VPWR VPWR _0556_ sky130_fd_sc_hd__or3_2
XFILLER_52_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_32_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1088_ _0487_ _0494_ _0495_ net225 VGND VGND VPWR VPWR _0497_ sky130_fd_sc_hd__a31o_1
XFILLER_20_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_20_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_57_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_57_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_28_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_43_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_28_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_7_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_7_135 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_47_90 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2060_ lf_inst.zero_error_count\[3\] lf_inst.zero_error_count\[2\] net205 lf_inst.zero_error_count\[4\]
+ VGND VGND VPWR VPWR _0450_ sky130_fd_sc_hd__o211a_1
XFILLER_14_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_19_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_34_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1913_ net142 _1017_ VGND VGND VPWR VPWR _0351_ sky130_fd_sc_hd__xnor2_1
X_1844_ lf_inst.integrator\[5\] net136 VGND VGND VPWR VPWR _0293_ sky130_fd_sc_hd__xnor2_4
X_1775_ _0452_ unlock_timer\[0\] VGND VGND VPWR VPWR _0241_ sky130_fd_sc_hd__and2_1
XFILLER_57_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_27_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1209_ dco_inst.accumulator\[23\] net82 VGND VGND VPWR VPWR _0601_ sky130_fd_sc_hd__or2_1
XFILLER_43_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2189_ net212 _0120_ VGND VGND VPWR VPWR div_inst.counter\[6\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_26_284 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_17_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1560_ _0840_ _0940_ _0941_ _0942_ VGND VGND VPWR VPWR _0943_ sky130_fd_sc_hd__or4_1
XFILLER_39_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_39_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1491_ div_inst.counter\[16\] _0821_ VGND VGND VPWR VPWR _0874_ sky130_fd_sc_hd__xnor2_1
XFILLER_12_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2112_ clknet_4_5_0_sys_clk _0050_ VGND VGND VPWR VPWR lf_inst.integrator\[13\] sky130_fd_sc_hd__dfxtp_1
XFILLER_54_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2043_ _0885_ net107 VGND VGND VPWR VPWR _0129_ sky130_fd_sc_hd__nor2_1
X_1827_ _0276_ _0277_ _0278_ VGND VGND VPWR VPWR _0279_ sky130_fd_sc_hd__o21a_1
X_1758_ _0225_ _0226_ VGND VGND VPWR VPWR _0227_ sky130_fd_sc_hd__xnor2_1
X_1689_ net238 net45 VGND VGND VPWR VPWR _0167_ sky130_fd_sc_hd__and2_1
XFILLER_38_59 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_38_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_0_130 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_13_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_28_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_60_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1474_ net275 _0853_ VGND VGND VPWR VPWR _0857_ sky130_fd_sc_hd__nor2_1
Xfanout209 lf_inst.integrator\[0\] VGND VGND VPWR VPWR net209 sky130_fd_sc_hd__buf_1
X_1612_ net167 _0982_ VGND VGND VPWR VPWR _0983_ sky130_fd_sc_hd__nor2_1
X_1543_ _0923_ _0917_ _0922_ VGND VGND VPWR VPWR _0926_ sky130_fd_sc_hd__and3b_1
X_2026_ net176 _0447_ _0446_ _0448_ VGND VGND VPWR VPWR _0113_ sky130_fd_sc_hd__a31o_1
XFILLER_35_340 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_10_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_24_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_40_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_49_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_60_118 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_45_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_18_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_18_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_53_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_5_200 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_59_482 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1190_ _0583_ _0584_ VGND VGND VPWR VPWR _0585_ sky130_fd_sc_hd__nand2_1
XFILLER_39_80 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xinput9 div_val[17] VGND VGND VPWR VPWR net9 sky130_fd_sc_hd__buf_1
XTAP_TAPCELL_ROW_42_382 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_59_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1457_ net25 _0837_ _0839_ VGND VGND VPWR VPWR _0840_ sky130_fd_sc_hd__o21ai_1
X_1526_ net267 _0908_ net124 net12 VGND VGND VPWR VPWR _0909_ sky130_fd_sc_hd__o2bb2a_1
XFILLER_35_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_27_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1388_ _0661_ _0770_ VGND VGND VPWR VPWR _0771_ sky130_fd_sc_hd__nor2_1
X_2009_ net203 net224 net207 net132 VGND VGND VPWR VPWR _0434_ sky130_fd_sc_hd__a31o_1
XFILLER_23_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_58_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_48_419 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_18_104 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_41_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_31_319 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1311_ _0692_ div_inst.counter\[27\] _0676_ VGND VGND VPWR VPWR _0694_ sky130_fd_sc_hd__and3b_1
X_1242_ net258 _0629_ _0630_ VGND VGND VPWR VPWR _0030_ sky130_fd_sc_hd__and3_1
XFILLER_49_295 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_49_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1173_ _0558_ _0568_ _0569_ VGND VGND VPWR VPWR _0570_ sky130_fd_sc_hd__a21oi_1
XFILLER_2_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_2_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_10_Right_10 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_32_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_17_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1509_ net6 _0889_ _0891_ net262 VGND VGND VPWR VPWR _0892_ sky130_fd_sc_hd__a22o_1
XFILLER_23_140 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_11_313 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_23_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_11_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_26_Left_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1860_ _0283_ _0288_ _0305_ _0289_ VGND VGND VPWR VPWR _0306_ sky130_fd_sc_hd__or4_4
XFILLER_14_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xinput56 initial_freq[30] VGND VGND VPWR VPWR net56 sky130_fd_sc_hd__clkbuf_1
Xinput45 initial_freq[20] VGND VGND VPWR VPWR net45 sky130_fd_sc_hd__clkbuf_1
X_1791_ pfd_inst.state\[0\] net204 VGND VGND VPWR VPWR _0251_ sky130_fd_sc_hd__and2b_1
Xinput34 initial_freq[10] VGND VGND VPWR VPWR net34 sky130_fd_sc_hd__clkbuf_1
Xinput23 div_val[2] VGND VGND VPWR VPWR net23 sky130_fd_sc_hd__buf_1
Xinput12 div_val[1] VGND VGND VPWR VPWR net12 sky130_fd_sc_hd__buf_1
X_1225_ _0608_ _0614_ VGND VGND VPWR VPWR _0616_ sky130_fd_sc_hd__nand2_1
XFILLER_37_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1087_ _0487_ _0495_ _0494_ VGND VGND VPWR VPWR _0496_ sky130_fd_sc_hd__a21oi_1
X_1156_ _0542_ _0548_ VGND VGND VPWR VPWR _0555_ sky130_fd_sc_hd__nor2_1
X_1989_ _0207_ net131 VGND VGND VPWR VPWR _0417_ sky130_fd_sc_hd__nor2_1
XFILLER_20_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_57_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_43_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_43_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_43_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_7_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_7_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_11_198 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_22_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_34_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_34_224 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_19_232 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1843_ net174 _0290_ _0291_ _0292_ VGND VGND VPWR VPWR _0086_ sky130_fd_sc_hd__a31o_1
XFILLER_8_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_8_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1912_ net301 net152 _1007_ _0350_ VGND VGND VPWR VPWR _0097_ sky130_fd_sc_hd__a211o_1
X_1774_ net99 net227 VGND VGND VPWR VPWR _0240_ sky130_fd_sc_hd__nor2_1
XFILLER_57_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1208_ net258 _0599_ _0600_ VGND VGND VPWR VPWR _0026_ sky130_fd_sc_hd__and3_1
XFILLER_43_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_25_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1139_ net229 _0540_ VGND VGND VPWR VPWR _0017_ sky130_fd_sc_hd__nor2_1
X_2188_ net212 _0119_ VGND VGND VPWR VPWR div_inst.counter\[5\] sky130_fd_sc_hd__dfxtp_1
XFILLER_4_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_48_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_3_150 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_17_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_26_285 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1490_ _0823_ _0872_ VGND VGND VPWR VPWR _0873_ sky130_fd_sc_hd__or2_1
X_2042_ _0886_ net104 VGND VGND VPWR VPWR _0128_ sky130_fd_sc_hd__nor2_1
X_2111_ clknet_4_4_0_sys_clk _0049_ VGND VGND VPWR VPWR lf_inst.integrator\[12\] sky130_fd_sc_hd__dfxtp_2
XPHY_EDGE_ROW_8_Right_8 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_17_230 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_22_227 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_29_Left_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1826_ _0276_ _0277_ net166 VGND VGND VPWR VPWR _0278_ sky130_fd_sc_hd__a21oi_1
X_1757_ _0215_ _0219_ VGND VGND VPWR VPWR _0226_ sky130_fd_sc_hd__nand2_1
XPHY_EDGE_ROW_39_Right_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1688_ _0165_ VGND VGND VPWR VPWR _0166_ sky130_fd_sc_hd__inv_2
XFILLER_38_16 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_13_Left_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_57_146 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_57_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_54_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_0_131 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_54_59 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_48_Right_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_23_266 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_57_Right_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_48_124 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_44_352 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_44_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_8_220 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_8_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1611_ _0978_ _0981_ VGND VGND VPWR VPWR _0982_ sky130_fd_sc_hd__xnor2_1
X_1473_ _0848_ _0855_ VGND VGND VPWR VPWR _0856_ sky130_fd_sc_hd__nor2_1
X_1542_ _0913_ _0915_ _0924_ VGND VGND VPWR VPWR _0925_ sky130_fd_sc_hd__a21o_1
X_2025_ net91 net157 _0239_ VGND VGND VPWR VPWR _0448_ sky130_fd_sc_hd__a21o_1
XFILLER_39_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_27_308 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_50_322 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_24_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1809_ net255 _0263_ _0264_ VGND VGND VPWR VPWR _0080_ sky130_fd_sc_hd__and3_1
XFILLER_49_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_41_311 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_5_212 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_14_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_30_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_59_483 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_39_92 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_36_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_42_383 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1456_ div_inst.counter\[31\] _0836_ _0838_ VGND VGND VPWR VPWR _0839_ sky130_fd_sc_hd__a21oi_1
X_1525_ net123 net122 VGND VGND VPWR VPWR _0908_ sky130_fd_sc_hd__xnor2_1
X_1387_ net266 _0660_ VGND VGND VPWR VPWR _0770_ sky130_fd_sc_hd__and2_1
X_2008_ net175 _0431_ _0432_ _0433_ VGND VGND VPWR VPWR _0110_ sky130_fd_sc_hd__a31o_1
XFILLER_35_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_27_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_50_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_23_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_18_116 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_56_464 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_47_Left_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1241_ _0626_ _0627_ _0624_ VGND VGND VPWR VPWR _0630_ sky130_fd_sc_hd__o21bai_1
X_1310_ net269 _0675_ VGND VGND VPWR VPWR _0693_ sky130_fd_sc_hd__xor2_1
XFILLER_49_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_37_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_1_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_56_Left_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1172_ _0553_ _0561_ _0560_ VGND VGND VPWR VPWR _0569_ sky130_fd_sc_hd__a21oi_1
XFILLER_2_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_32_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_21_19 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput100 net219 VGND VGND VPWR VPWR pll_out sky130_fd_sc_hd__buf_2
X_1439_ div_inst.counter\[17\] div_inst.counter\[16\] VGND VGND VPWR VPWR _0822_ sky130_fd_sc_hd__and2_1
X_1508_ div_inst.counter\[12\] _0817_ VGND VGND VPWR VPWR _0891_ sky130_fd_sc_hd__xor2_1
XFILLER_11_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_2_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_36_60 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_1_Left_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xinput13 div_val[20] VGND VGND VPWR VPWR net13 sky130_fd_sc_hd__buf_1
XFILLER_36_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1790_ net141 _0250_ VGND VGND VPWR VPWR _0075_ sky130_fd_sc_hd__and2_1
Xinput57 initial_freq[31] VGND VGND VPWR VPWR net57 sky130_fd_sc_hd__clkbuf_1
Xinput24 div_val[30] VGND VGND VPWR VPWR net24 sky130_fd_sc_hd__buf_1
Xinput46 initial_freq[21] VGND VGND VPWR VPWR net46 sky130_fd_sc_hd__clkbuf_1
Xinput35 initial_freq[11] VGND VGND VPWR VPWR net35 sky130_fd_sc_hd__buf_1
X_1224_ _0608_ _0614_ VGND VGND VPWR VPWR _0615_ sky130_fd_sc_hd__or2_1
X_1155_ _0552_ _0553_ VGND VGND VPWR VPWR _0554_ sky130_fd_sc_hd__and2_1
X_1086_ dco_inst.accumulator\[5\] net94 _0483_ _0484_ _0482_ VGND VGND VPWR VPWR _0495_
+ sky130_fd_sc_hd__a221o_1
X_1988_ net314 net162 _0416_ net178 _0201_ VGND VGND VPWR VPWR _0107_ sky130_fd_sc_hd__a221o_1
XFILLER_32_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_20_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_57_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout190 lf_inst.error_in\[1\] VGND VGND VPWR VPWR net190 sky130_fd_sc_hd__buf_4
XFILLER_47_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_34_236 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1773_ net292 net156 _0237_ _0238_ _0239_ VGND VGND VPWR VPWR _0068_ sky130_fd_sc_hd__a221o_1
X_1842_ net225 net59 net93 net148 VGND VGND VPWR VPWR _0292_ sky130_fd_sc_hd__a22o_1
XFILLER_8_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_8_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1911_ _0348_ _0349_ VGND VGND VPWR VPWR _0350_ sky130_fd_sc_hd__nor2_1
XFILLER_57_306 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1207_ _0597_ _0598_ _0593_ _0594_ VGND VGND VPWR VPWR _0600_ sky130_fd_sc_hd__o211ai_2
X_2187_ net212 _0118_ VGND VGND VPWR VPWR div_inst.counter\[4\] sky130_fd_sc_hd__dfxtp_1
XFILLER_25_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1069_ _0480_ net243 _0479_ VGND VGND VPWR VPWR _0007_ sky130_fd_sc_hd__and3b_1
X_1138_ _0538_ _0539_ VGND VGND VPWR VPWR _0540_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_3_151 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_26_286 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_54_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2041_ _0889_ net103 VGND VGND VPWR VPWR _0127_ sky130_fd_sc_hd__nor2_1
X_2110_ clknet_4_1_0_sys_clk _0048_ VGND VGND VPWR VPWR lf_inst.integrator\[11\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_17_231 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1756_ _0223_ _0224_ VGND VGND VPWR VPWR _0225_ sky130_fd_sc_hd__nand2_1
XFILLER_30_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1825_ lf_inst.integrator\[1\] _0268_ VGND VGND VPWR VPWR _0277_ sky130_fd_sc_hd__nand2_1
XFILLER_57_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1687_ _0161_ _0164_ VGND VGND VPWR VPWR _0165_ sky130_fd_sc_hd__xnor2_2
XFILLER_57_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_54_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_0_132 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_21_294 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_23_267 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_48_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_36_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_28_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_14_212 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_30_Left_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_8_232 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_8_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_12_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1610_ _0979_ _0980_ VGND VGND VPWR VPWR _0981_ sky130_fd_sc_hd__or2_1
X_1472_ net20 _0847_ _0851_ net273 _0854_ VGND VGND VPWR VPWR _0855_ sky130_fd_sc_hd__o221a_1
XFILLER_39_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1541_ net28 _0914_ _0921_ net29 VGND VGND VPWR VPWR _0924_ sky130_fd_sc_hd__a22o_1
X_2024_ _0444_ _0439_ _0236_ VGND VGND VPWR VPWR _0447_ sky130_fd_sc_hd__o21ai_1
XFILLER_50_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_50_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1739_ net194 lf_inst.integrator\[27\] VGND VGND VPWR VPWR _0210_ sky130_fd_sc_hd__xor2_1
XFILLER_40_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1808_ lf_inst.zero_error_count\[1\] lf_inst.zero_error_count\[0\] lf_inst.zero_error_count\[2\]
+ VGND VGND VPWR VPWR _0264_ sky130_fd_sc_hd__a21o_1
XTAP_TAPCELL_ROW_20_248 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_18_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_45_139 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_41_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_38_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_26_342 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_14_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_59_484 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_55_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_42_384 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1524_ net265 _0903_ _0905_ net26 VGND VGND VPWR VPWR _0907_ sky130_fd_sc_hd__o22a_1
XFILLER_59_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1455_ div_inst.counter\[31\] div_inst.counter\[30\] _0834_ VGND VGND VPWR VPWR _0838_
+ sky130_fd_sc_hd__and3b_1
X_1386_ net28 _0661_ VGND VGND VPWR VPWR _0769_ sky130_fd_sc_hd__xnor2_1
X_2007_ net87 net156 _0222_ VGND VGND VPWR VPWR _0433_ sky130_fd_sc_hd__a21o_1
XFILLER_35_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_23_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_23_345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_51_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_2_227 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_56_465 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_18_128 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_41_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_14_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_41_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1240_ _0622_ _0623_ _0626_ _0627_ VGND VGND VPWR VPWR _0629_ sky130_fd_sc_hd__a211o_1
X_1171_ _0554_ _0562_ VGND VGND VPWR VPWR _0568_ sky130_fd_sc_hd__and2_1
XFILLER_2_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_47_410 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_17_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_32_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_32_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_30_310 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_20_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1507_ net7 _0886_ _0889_ net6 VGND VGND VPWR VPWR _0890_ sky130_fd_sc_hd__o22a_1
XFILLER_55_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1438_ net118 _0818_ _0820_ VGND VGND VPWR VPWR _0821_ sky130_fd_sc_hd__and3_1
X_1369_ net271 _0664_ VGND VGND VPWR VPWR _0752_ sky130_fd_sc_hd__xor2_1
XTAP_TAPCELL_ROW_53_446 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_23_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_46_267 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_46_223 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_36_72 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_52_60 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xinput25 div_val[31] VGND VGND VPWR VPWR net25 sky130_fd_sc_hd__buf_1
Xinput14 div_val[21] VGND VGND VPWR VPWR net14 sky130_fd_sc_hd__buf_1
Xinput36 initial_freq[12] VGND VGND VPWR VPWR net36 sky130_fd_sc_hd__clkbuf_1
Xinput47 initial_freq[22] VGND VGND VPWR VPWR net47 sky130_fd_sc_hd__clkbuf_1
Xinput58 initial_freq[3] VGND VGND VPWR VPWR net58 sky130_fd_sc_hd__clkbuf_1
X_1223_ _0612_ _0613_ VGND VGND VPWR VPWR _0614_ sky130_fd_sc_hd__nand2_1
XFILLER_28_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1154_ dco_inst.accumulator\[16\] net74 VGND VGND VPWR VPWR _0553_ sky130_fd_sc_hd__nand2_1
XFILLER_60_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_32_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1085_ _0492_ _0493_ VGND VGND VPWR VPWR _0494_ sky130_fd_sc_hd__and2b_1
X_1987_ _0412_ _0415_ VGND VGND VPWR VPWR _0416_ sky130_fd_sc_hd__xor2_1
XFILLER_57_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_28_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_7_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_11_123 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_11_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_22_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_47_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xfanout180 net182 VGND VGND VPWR VPWR net180 sky130_fd_sc_hd__clkbuf_2
XFILLER_19_256 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_34_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_34_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_19_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1910_ _0340_ _0345_ _0347_ net168 VGND VGND VPWR VPWR _0349_ sky130_fd_sc_hd__a31o_1
X_1772_ net233 net57 VGND VGND VPWR VPWR _0239_ sky130_fd_sc_hd__and2_1
XFILLER_8_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1841_ _0283_ _0288_ _0289_ VGND VGND VPWR VPWR _0291_ sky130_fd_sc_hd__or3_1
XFILLER_57_318 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_6_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1206_ _0593_ _0594_ _0597_ _0598_ VGND VGND VPWR VPWR _0599_ sky130_fd_sc_hd__a211o_1
XFILLER_27_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_25_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1137_ _0531_ _0532_ _0533_ VGND VGND VPWR VPWR _0539_ sky130_fd_sc_hd__o21a_1
X_2186_ net211 _0117_ VGND VGND VPWR VPWR div_inst.counter\[3\] sky130_fd_sc_hd__dfxtp_1
XFILLER_33_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_25_259 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1068_ _0476_ _0477_ _0478_ VGND VGND VPWR VPWR _0480_ sky130_fd_sc_hd__and3_1
XFILLER_48_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_26_287 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_16_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_3_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2040_ _0891_ net103 VGND VGND VPWR VPWR _0126_ sky130_fd_sc_hd__nor2_1
XFILLER_15_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_17_232 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_22_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1755_ net192 lf_inst.integrator\[29\] VGND VGND VPWR VPWR _0224_ sky130_fd_sc_hd__nand2_1
X_1686_ _0154_ _0162_ _0163_ VGND VGND VPWR VPWR _0164_ sky130_fd_sc_hd__a21o_1
XFILLER_30_295 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1824_ _0273_ _0275_ VGND VGND VPWR VPWR _0276_ sky130_fd_sc_hd__nand2_1
XFILLER_57_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_38_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_54_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2169_ clknet_4_13_0_sys_clk _0100_ VGND VGND VPWR VPWR net76 sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_0_133 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_122 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_23_268 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_14_213 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_60_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_5_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1540_ net31 _0916_ _0919_ net263 VGND VGND VPWR VPWR _0923_ sky130_fd_sc_hd__a22o_1
X_1471_ net273 _0851_ _0853_ net275 VGND VGND VPWR VPWR _0854_ sky130_fd_sc_hd__a22o_1
XFILLER_39_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_39_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_10_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2023_ _0236_ _0439_ _0444_ VGND VGND VPWR VPWR _0446_ sky130_fd_sc_hd__or3_1
XFILLER_35_354 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_40_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1807_ lf_inst.zero_error_count\[2\] _0256_ net116 _0262_ VGND VGND VPWR VPWR _0263_
+ sky130_fd_sc_hd__a22o_1
XTAP_TAPCELL_ROW_20_249 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1738_ net337 net158 _0208_ _0209_ VGND VGND VPWR VPWR _0063_ sky130_fd_sc_hd__a211o_1
X_1669_ net169 _0148_ VGND VGND VPWR VPWR _0149_ sky130_fd_sc_hd__nor2_1
XFILLER_53_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_53_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_41_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_30_63 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_5_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_14_64 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_14_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_30_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_59_485 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_29_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_44_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_42_385 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_58_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1454_ _0835_ _0836_ VGND VGND VPWR VPWR _0837_ sky130_fd_sc_hd__nand2_1
X_1523_ net265 _0903_ _0905_ net26 VGND VGND VPWR VPWR _0906_ sky130_fd_sc_hd__a22o_1
X_1385_ div_inst.counter\[7\] _0764_ _0767_ div_inst.counter\[6\] VGND VGND VPWR VPWR
+ _0768_ sky130_fd_sc_hd__o22a_1
X_2006_ _0427_ _0430_ VGND VGND VPWR VPWR _0432_ sky130_fd_sc_hd__or2_1
XFILLER_50_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_33_330 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_23_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_58_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_58_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_56_466 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_25_30 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_41_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_26_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_44_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_49_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_47_411 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1170_ _0565_ _0566_ VGND VGND VPWR VPWR _0567_ sky130_fd_sc_hd__nand2_1
XFILLER_32_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_32_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_20_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_30_311 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1437_ div_inst.counter\[15\] div_inst.counter\[14\] VGND VGND VPWR VPWR _0820_ sky130_fd_sc_hd__and2_1
X_1506_ _0819_ _0888_ VGND VGND VPWR VPWR _0889_ sky130_fd_sc_hd__or2_1
XFILLER_55_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1299_ net268 _0676_ net22 VGND VGND VPWR VPWR _0682_ sky130_fd_sc_hd__o21ai_1
XFILLER_46_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1368_ _0665_ _0750_ div_inst.counter\[11\] VGND VGND VPWR VPWR _0751_ sky130_fd_sc_hd__a21o_1
XTAP_TAPCELL_ROW_53_447 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_7_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_23_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_23_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_11_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_46_202 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_46_235 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_52_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xinput48 initial_freq[23] VGND VGND VPWR VPWR net48 sky130_fd_sc_hd__clkbuf_1
Xinput15 div_val[22] VGND VGND VPWR VPWR net15 sky130_fd_sc_hd__clkbuf_1
Xinput59 initial_freq[4] VGND VGND VPWR VPWR net59 sky130_fd_sc_hd__clkbuf_1
Xinput26 div_val[3] VGND VGND VPWR VPWR net26 sky130_fd_sc_hd__buf_1
Xinput37 initial_freq[13] VGND VGND VPWR VPWR net37 sky130_fd_sc_hd__clkbuf_1
XFILLER_42_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1222_ _0583_ _0584_ _0596_ _0611_ VGND VGND VPWR VPWR _0613_ sky130_fd_sc_hd__a211o_1
XFILLER_37_268 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_37_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_37_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1084_ dco_inst.accumulator\[6\] net95 VGND VGND VPWR VPWR _0493_ sky130_fd_sc_hd__or2_1
X_1153_ dco_inst.accumulator\[16\] net74 VGND VGND VPWR VPWR _0552_ sky130_fd_sc_hd__or2_1
XFILLER_60_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1986_ _0199_ net128 VGND VGND VPWR VPWR _0415_ sky130_fd_sc_hd__xnor2_1
XTAP_TAPCELL_ROW_50_428 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_20_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_28_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_28_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_11_135 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout181 net182 VGND VGND VPWR VPWR net181 sky130_fd_sc_hd__buf_1
Xfanout170 net171 VGND VGND VPWR VPWR net170 sky130_fd_sc_hd__dlymetal6s2s_1
Xfanout192 net194 VGND VGND VPWR VPWR net192 sky130_fd_sc_hd__buf_1
XFILLER_19_268 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_42_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1840_ _0283_ _0289_ _0288_ VGND VGND VPWR VPWR _0290_ sky130_fd_sc_hd__o21ai_1
X_1771_ net192 _0236_ net176 VGND VGND VPWR VPWR _0238_ sky130_fd_sc_hd__o21a_1
XFILLER_8_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1205_ _0579_ _0589_ _0588_ VGND VGND VPWR VPWR _0598_ sky130_fd_sc_hd__a21oi_2
XFILLER_25_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1067_ _0476_ _0477_ _0478_ VGND VGND VPWR VPWR _0479_ sky130_fd_sc_hd__a21o_1
X_2185_ net211 _0116_ VGND VGND VPWR VPWR div_inst.counter\[2\] sky130_fd_sc_hd__dfxtp_1
X_1136_ _0536_ _0537_ VGND VGND VPWR VPWR _0538_ sky130_fd_sc_hd__nand2_1
X_1969_ _0184_ net132 VGND VGND VPWR VPWR _0400_ sky130_fd_sc_hd__xnor2_1
XFILLER_33_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_4_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_31_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_26_288 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_24_260 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_58_60 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_17_233 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1823_ lf_inst.integrator\[2\] net138 VGND VGND VPWR VPWR _0275_ sky130_fd_sc_hd__or2_1
X_1754_ net192 lf_inst.integrator\[29\] VGND VGND VPWR VPWR _0223_ sky130_fd_sc_hd__or2_1
X_1685_ _1026_ _1029_ _0151_ VGND VGND VPWR VPWR _0163_ sky130_fd_sc_hd__nand3_1
XFILLER_57_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_54_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_53_311 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2168_ clknet_4_6_0_sys_clk _0099_ VGND VGND VPWR VPWR net75 sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_0_123 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1119_ dco_inst.accumulator\[11\] net69 VGND VGND VPWR VPWR _0523_ sky130_fd_sc_hd__nor2_1
Xclkbuf_4_1_0_sys_clk clknet_0_sys_clk VGND VGND VPWR VPWR clknet_4_1_0_sys_clk sky130_fd_sc_hd__clkbuf_8
X_2099_ clknet_4_3_0_sys_clk _0037_ VGND VGND VPWR VPWR lf_inst.integrator\[1\] sky130_fd_sc_hd__dfxtp_1
XPHY_EDGE_ROW_17_Right_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_23_269 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_48_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_26_Right_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_56_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_35_Right_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_14_214 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1470_ div_inst.counter\[24\] _0829_ VGND VGND VPWR VPWR _0853_ sky130_fd_sc_hd__xnor2_1
XPHY_EDGE_ROW_44_Right_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_53_Right_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2022_ net298 net157 _0234_ _0445_ VGND VGND VPWR VPWR _0112_ sky130_fd_sc_hd__a211o_1
X_1806_ _0261_ VGND VGND VPWR VPWR _0262_ sky130_fd_sc_hd__inv_2
XPHY_EDGE_ROW_17_Left_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1737_ net235 net51 VGND VGND VPWR VPWR _0209_ sky130_fd_sc_hd__and2_1
X_1668_ _1030_ _0147_ VGND VGND VPWR VPWR _0148_ sky130_fd_sc_hd__nand2_1
X_1599_ net224 net185 VGND VGND VPWR VPWR _0971_ sky130_fd_sc_hd__nand2b_1
XFILLER_41_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_14_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_14_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_30_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_30_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_5_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_59_486 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_44_174 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_44_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1453_ div_inst.counter\[30\] _0834_ VGND VGND VPWR VPWR _0836_ sky130_fd_sc_hd__nand2_1
XFILLER_4_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1522_ _0808_ _0904_ VGND VGND VPWR VPWR _0905_ sky130_fd_sc_hd__or2_1
X_2005_ _0427_ _0430_ VGND VGND VPWR VPWR _0431_ sky130_fd_sc_hd__nand2_1
X_1384_ _0662_ _0766_ VGND VGND VPWR VPWR _0767_ sky130_fd_sc_hd__and2_1
XFILLER_50_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_50_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_33_331 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_2_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_56_467 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_25_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_14_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_14_336 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_41_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_49_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_47_412 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_32_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_32_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_30_312 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1505_ net119 _0818_ VGND VGND VPWR VPWR _0888_ sky130_fd_sc_hd__nor2_1
X_1436_ net119 _0818_ VGND VGND VPWR VPWR _0819_ sky130_fd_sc_hd__and2_1
X_1367_ net271 _0664_ net3 VGND VGND VPWR VPWR _0750_ sky130_fd_sc_hd__o21ai_1
XFILLER_55_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_53_448 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1298_ div_inst.counter\[30\] _0679_ VGND VGND VPWR VPWR _0681_ sky130_fd_sc_hd__xor2_1
XPHY_EDGE_ROW_43_Left_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_23_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_23_199 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_52_Left_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_36_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xinput16 div_val[23] VGND VGND VPWR VPWR net16 sky130_fd_sc_hd__buf_1
Xinput49 initial_freq[24] VGND VGND VPWR VPWR net49 sky130_fd_sc_hd__buf_1
XFILLER_6_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xinput27 div_val[4] VGND VGND VPWR VPWR net27 sky130_fd_sc_hd__clkbuf_1
Xinput38 initial_freq[14] VGND VGND VPWR VPWR net38 sky130_fd_sc_hd__clkbuf_1
X_1221_ dco_inst.accumulator\[23\] net82 _0598_ _0610_ _0609_ VGND VGND VPWR VPWR
+ _0612_ sky130_fd_sc_hd__a221oi_4
XFILLER_37_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1083_ dco_inst.accumulator\[6\] net95 VGND VGND VPWR VPWR _0492_ sky130_fd_sc_hd__and2_1
X_1152_ net230 _0550_ _0551_ VGND VGND VPWR VPWR _0019_ sky130_fd_sc_hd__nor3_1
XFILLER_60_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_50_429 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1985_ _0199_ net128 VGND VGND VPWR VPWR _0414_ sky130_fd_sc_hd__and2_1
XFILLER_9_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1419_ _0785_ _0801_ _0779_ _0784_ VGND VGND VPWR VPWR _0802_ sky130_fd_sc_hd__and4bb_1
XFILLER_28_269 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_7_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_11_147 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_11_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_5_Left_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_3_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_3_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout193 net194 VGND VGND VPWR VPWR net193 sky130_fd_sc_hd__clkbuf_1
Xfanout171 _0965_ VGND VGND VPWR VPWR net171 sky130_fd_sc_hd__buf_1
Xfanout160 net163 VGND VGND VPWR VPWR net160 sky130_fd_sc_hd__clkbuf_2
Xfanout182 net183 VGND VGND VPWR VPWR net182 sky130_fd_sc_hd__buf_1
XFILLER_19_203 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_19_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1770_ net193 _0236_ VGND VGND VPWR VPWR _0237_ sky130_fd_sc_hd__nand2_1
XFILLER_42_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1204_ _0585_ _0595_ VGND VGND VPWR VPWR _0597_ sky130_fd_sc_hd__and2_1
XFILLER_33_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2184_ net211 _0115_ VGND VGND VPWR VPWR div_inst.counter\[1\] sky130_fd_sc_hd__dfxtp_1
XFILLER_40_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1066_ _0472_ _0473_ _0471_ VGND VGND VPWR VPWR _0478_ sky130_fd_sc_hd__a21bo_1
X_1135_ dco_inst.accumulator\[13\] net71 VGND VGND VPWR VPWR _0537_ sky130_fd_sc_hd__nand2_1
XFILLER_18_291 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1968_ net315 net147 _0399_ VGND VGND VPWR VPWR _0104_ sky130_fd_sc_hd__o21a_1
X_1899_ net308 net154 _0339_ net172 _0994_ VGND VGND VPWR VPWR _0095_ sky130_fd_sc_hd__a221o_1
XFILLER_0_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_48_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_17_10 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_33_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_33_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_26_289 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_24_272 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_58_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_3_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_17_234 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1753_ net291 net156 _0221_ net175 _0222_ VGND VGND VPWR VPWR _0065_ sky130_fd_sc_hd__a221o_1
XFILLER_30_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1822_ lf_inst.integrator\[2\] net136 VGND VGND VPWR VPWR _0274_ sky130_fd_sc_hd__nor2_1
Xmax_cap113 _0162_ VGND VGND VPWR VPWR net113 sky130_fd_sc_hd__clkbuf_1
X_1684_ _1010_ _1011_ _1014_ _1020_ _1027_ VGND VGND VPWR VPWR _0162_ sky130_fd_sc_hd__a2111oi_1
XFILLER_53_323 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2167_ clknet_4_7_0_sys_clk _0098_ VGND VGND VPWR VPWR net74 sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_0_124 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_53_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2098_ clknet_4_9_0_sys_clk _0002_ VGND VGND VPWR VPWR pfd_inst.state\[2\] sky130_fd_sc_hd__dfxtp_1
X_1118_ net249 _0521_ _0522_ VGND VGND VPWR VPWR _0014_ sky130_fd_sc_hd__and3_1
XFILLER_13_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_4_5_0_sys_clk clknet_0_sys_clk VGND VGND VPWR VPWR clknet_4_5_0_sys_clk sky130_fd_sc_hd__clkbuf_8
X_1049_ _0069_ VGND VGND VPWR VPWR _0003_ sky130_fd_sc_hd__inv_2
XFILLER_0_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_44_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_12_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_12_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_14_215 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_5_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2021_ _0444_ net175 _0443_ VGND VGND VPWR VPWR _0445_ sky130_fd_sc_hd__and3b_1
X_1736_ net170 _0207_ VGND VGND VPWR VPWR _0208_ sky130_fd_sc_hd__nor2_1
X_1805_ lf_inst.zero_error_count\[2\] lf_inst.zero_error_count\[1\] lf_inst.zero_error_count\[0\]
+ VGND VGND VPWR VPWR _0261_ sky130_fd_sc_hd__and3_1
X_1667_ _1027_ _1028_ _1029_ VGND VGND VPWR VPWR _0147_ sky130_fd_sc_hd__nand3_1
X_1598_ net223 net188 VGND VGND VPWR VPWR _0970_ sky130_fd_sc_hd__and2b_1
XFILLER_38_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_38_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_26_323 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_41_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_5_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_59_487 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_34_Left_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_29_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_55_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_44_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_32_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_32_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1452_ div_inst.counter\[30\] _0834_ VGND VGND VPWR VPWR _0835_ sky130_fd_sc_hd__or2_1
XFILLER_4_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1521_ net123 net122 net121 VGND VGND VPWR VPWR _0904_ sky130_fd_sc_hd__a21oi_1
X_1383_ net28 net266 _0660_ net29 VGND VGND VPWR VPWR _0766_ sky130_fd_sc_hd__o31ai_1
X_2004_ _0428_ _0429_ VGND VGND VPWR VPWR _0430_ sky130_fd_sc_hd__nand2_1
XFILLER_27_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1719_ _0154_ net113 _0191_ _0192_ VGND VGND VPWR VPWR _0193_ sky130_fd_sc_hd__a31o_1
XTAP_TAPCELL_ROW_56_468 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_26_120 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_14_348 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_41_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_49_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_1_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_1_263 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_1_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_47_413 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_30_313 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1504_ net241 _0885_ _0886_ net7 VGND VGND VPWR VPWR _0887_ sky130_fd_sc_hd__a22o_1
XFILLER_55_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1366_ _0740_ _0748_ VGND VGND VPWR VPWR _0749_ sky130_fd_sc_hd__nand2_1
X_1435_ div_inst.counter\[12\] _0813_ _0814_ _0816_ VGND VGND VPWR VPWR _0818_ sky130_fd_sc_hd__and4_1
XTAP_TAPCELL_ROW_53_449 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1297_ div_inst.counter\[30\] _0679_ VGND VGND VPWR VPWR _0680_ sky130_fd_sc_hd__nor2_1
XFILLER_46_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_52_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xinput17 div_val[24] VGND VGND VPWR VPWR net17 sky130_fd_sc_hd__buf_1
XFILLER_6_333 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xinput28 div_val[5] VGND VGND VPWR VPWR net28 sky130_fd_sc_hd__buf_1
Xinput39 initial_freq[15] VGND VGND VPWR VPWR net39 sky130_fd_sc_hd__clkbuf_1
X_1220_ _0610_ VGND VGND VPWR VPWR _0611_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_9_182 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1151_ _0542_ _0547_ _0548_ _0549_ VGND VGND VPWR VPWR _0551_ sky130_fd_sc_hd__a211oi_1
XFILLER_45_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_37_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1082_ _0490_ _0491_ VGND VGND VPWR VPWR _0009_ sky130_fd_sc_hd__and2_1
XFILLER_60_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_60_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1984_ _0199_ net131 VGND VGND VPWR VPWR _0413_ sky130_fd_sc_hd__nor2_1
XFILLER_9_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_21_Left_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1349_ _0729_ _0730_ _0731_ _0725_ VGND VGND VPWR VPWR _0732_ sky130_fd_sc_hd__o31a_1
X_1418_ net124 net1 div_inst.counter\[2\] _0781_ VGND VGND VPWR VPWR _0801_ sky130_fd_sc_hd__a2bb2o_1
XFILLER_11_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_3_303 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_11_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_22_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_22_99 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_47_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xfanout161 net162 VGND VGND VPWR VPWR net161 sky130_fd_sc_hd__dlymetal6s2s_1
Xfanout183 _0964_ VGND VGND VPWR VPWR net183 sky130_fd_sc_hd__clkbuf_1
Xfanout150 net155 VGND VGND VPWR VPWR net150 sky130_fd_sc_hd__clkbuf_1
Xfanout172 net174 VGND VGND VPWR VPWR net172 sky130_fd_sc_hd__clkbuf_2
Xfanout194 net195 VGND VGND VPWR VPWR net194 sky130_fd_sc_hd__clkbuf_2
XFILLER_27_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_27_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_19_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_42_273 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1203_ _0595_ VGND VGND VPWR VPWR _0596_ sky130_fd_sc_hd__inv_2
X_2183_ net211 _0114_ VGND VGND VPWR VPWR div_inst.counter\[0\] sky130_fd_sc_hd__dfxtp_1
X_1134_ dco_inst.accumulator\[13\] net71 VGND VGND VPWR VPWR _0536_ sky130_fd_sc_hd__or2_1
X_1065_ dco_inst.accumulator\[3\] net92 VGND VGND VPWR VPWR _0477_ sky130_fd_sc_hd__or2_1
X_1967_ _0397_ _0398_ _0181_ VGND VGND VPWR VPWR _0399_ sky130_fd_sc_hd__o21ai_1
X_1898_ _0337_ _0338_ VGND VGND VPWR VPWR _0339_ sky130_fd_sc_hd__xnor2_1
XFILLER_56_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_16_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_16_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_24_284 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_3_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold6 pfd_inst.fb_sync\[0\] VGND VGND VPWR VPWR net281 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_17_235 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1752_ net233 net53 VGND VGND VPWR VPWR _0222_ sky130_fd_sc_hd__and2_1
X_1683_ _0159_ _0160_ VGND VGND VPWR VPWR _0161_ sky130_fd_sc_hd__nor2_1
X_1821_ lf_inst.integrator\[2\] net138 VGND VGND VPWR VPWR _0273_ sky130_fd_sc_hd__nand2_1
XFILLER_53_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2097_ clknet_4_9_0_sys_clk _0001_ VGND VGND VPWR VPWR pfd_inst.state\[1\] sky130_fd_sc_hd__dfxtp_1
X_1117_ _0509_ _0517_ _0518_ VGND VGND VPWR VPWR _0522_ sky130_fd_sc_hd__or3b_1
XTAP_TAPCELL_ROW_0_125 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2166_ clknet_4_7_0_sys_clk _0097_ VGND VGND VPWR VPWR net73 sky130_fd_sc_hd__dfxtp_1
Xclkbuf_4_9_0_sys_clk clknet_0_sys_clk VGND VGND VPWR VPWR clknet_4_9_0_sys_clk sky130_fd_sc_hd__clkbuf_8
XPHY_EDGE_ROW_3_Right_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_21_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1048_ net99 _0452_ net246 VGND VGND VPWR VPWR _0069_ sky130_fd_sc_hd__o21a_1
XFILLER_0_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_44_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_14_216 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_60_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_22_260 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_5_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2020_ _0441_ _0442_ VGND VGND VPWR VPWR _0444_ sky130_fd_sc_hd__nor2_4
XFILLER_47_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_47_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_35_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1735_ _0205_ _0206_ VGND VGND VPWR VPWR _0207_ sky130_fd_sc_hd__nand2_1
X_1666_ _1028_ _1029_ _1027_ VGND VGND VPWR VPWR _1030_ sky130_fd_sc_hd__a21o_1
X_1804_ lf_inst.zero_error_count\[1\] net338 net254 _0260_ VGND VGND VPWR VPWR _0079_
+ sky130_fd_sc_hd__o211a_1
X_1597_ net296 net149 _0969_ _0966_ VGND VGND VPWR VPWR _0046_ sky130_fd_sc_hd__a211o_1
XFILLER_41_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2149_ clknet_4_9_0_sys_clk _0080_ VGND VGND VPWR VPWR lf_inst.zero_error_count\[2\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_26_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_14_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_17_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1520_ _0809_ _0902_ VGND VGND VPWR VPWR _0903_ sky130_fd_sc_hd__or2_1
X_1451_ div_inst.counter\[29\] div_inst.counter\[28\] _0833_ VGND VGND VPWR VPWR _0834_
+ sky130_fd_sc_hd__and3_1
X_1382_ div_inst.counter\[7\] _0764_ VGND VGND VPWR VPWR _0765_ sky130_fd_sc_hd__nand2_1
X_2003_ _0220_ net131 VGND VGND VPWR VPWR _0429_ sky130_fd_sc_hd__nand2_1
XFILLER_35_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1718_ net198 lf_inst.integrator\[23\] _0174_ _0176_ VGND VGND VPWR VPWR _0192_ sky130_fd_sc_hd__a211o_1
X_1649_ _1010_ _1011_ _1014_ VGND VGND VPWR VPWR _1015_ sky130_fd_sc_hd__a21o_1
XFILLER_58_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_56_469 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_41_146 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_41_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_26_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_26_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_41_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_49_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_2_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_49_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_47_414 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1503_ div_inst.counter\[14\] _0819_ VGND VGND VPWR VPWR _0886_ sky130_fd_sc_hd__xnor2_1
XFILLER_55_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1296_ net24 _0677_ VGND VGND VPWR VPWR _0679_ sky130_fd_sc_hd__xor2_1
X_1365_ _0742_ _0743_ _0746_ _0747_ VGND VGND VPWR VPWR _0748_ sky130_fd_sc_hd__and4bb_1
X_1434_ _0815_ _0816_ VGND VGND VPWR VPWR _0817_ sky130_fd_sc_hd__nand2_1
XFILLER_23_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_23_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_23_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_11_68 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xinput18 div_val[25] VGND VGND VPWR VPWR net18 sky130_fd_sc_hd__clkbuf_1
XFILLER_6_345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xinput29 div_val[6] VGND VGND VPWR VPWR net29 sky130_fd_sc_hd__buf_1
XFILLER_28_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_9_183 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1150_ _0548_ _0549_ _0542_ _0547_ VGND VGND VPWR VPWR _0550_ sky130_fd_sc_hd__o211a_1
XFILLER_37_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1081_ _0482_ _0486_ _0489_ net242 VGND VGND VPWR VPWR _0491_ sky130_fd_sc_hd__o31a_1
X_1983_ _0405_ _0409_ VGND VGND VPWR VPWR _0412_ sky130_fd_sc_hd__nor2_1
X_1417_ _0691_ _0799_ _0680_ _0687_ _0689_ VGND VGND VPWR VPWR _0800_ sky130_fd_sc_hd__a2111o_1
X_1348_ div_inst.counter\[17\] _0669_ _0726_ VGND VGND VPWR VPWR _0731_ sky130_fd_sc_hd__and3_1
X_1279_ net28 net265 net29 _0660_ VGND VGND VPWR VPWR _0662_ sky130_fd_sc_hd__or4_2
XFILLER_3_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_315 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_22_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_22_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout162 net163 VGND VGND VPWR VPWR net162 sky130_fd_sc_hd__buf_1
Xfanout195 net201 VGND VGND VPWR VPWR net195 sky130_fd_sc_hd__buf_1
Xfanout173 net174 VGND VGND VPWR VPWR net173 sky130_fd_sc_hd__buf_1
Xfanout184 net98 VGND VGND VPWR VPWR net184 sky130_fd_sc_hd__buf_1
XTAP_TAPCELL_ROW_6_164 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout151 net154 VGND VGND VPWR VPWR net151 sky130_fd_sc_hd__dlymetal6s2s_1
Xfanout140 _0271_ VGND VGND VPWR VPWR net140 sky130_fd_sc_hd__clkbuf_2
XFILLER_27_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_42_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_6_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2182_ clknet_4_10_0_sys_clk _0113_ VGND VGND VPWR VPWR net91 sky130_fd_sc_hd__dfxtp_1
X_1202_ _0580_ _0590_ VGND VGND VPWR VPWR _0595_ sky130_fd_sc_hd__and2_1
X_1064_ dco_inst.accumulator\[3\] net92 VGND VGND VPWR VPWR _0476_ sky130_fd_sc_hd__nand2_1
X_1133_ net228 _0535_ VGND VGND VPWR VPWR _0016_ sky130_fd_sc_hd__nor2_1
X_1966_ _0394_ _0396_ net260 VGND VGND VPWR VPWR _0398_ sky130_fd_sc_hd__o21ai_1
X_1897_ _0987_ net139 _0334_ VGND VGND VPWR VPWR _0338_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_56_333 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_49_Left_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_33_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_24_296 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_3_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold7 pfd_inst.ref_sync\[0\] VGND VGND VPWR VPWR net282 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_25_280 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_15_263 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1820_ net223 net208 net185 VGND VGND VPWR VPWR _0272_ sky130_fd_sc_hd__or3b_4
X_1751_ _0220_ VGND VGND VPWR VPWR _0221_ sky130_fd_sc_hd__inv_2
X_1682_ net196 lf_inst.integrator\[20\] VGND VGND VPWR VPWR _0160_ sky130_fd_sc_hd__and2_1
X_1047_ net255 _0459_ _0464_ VGND VGND VPWR VPWR _0002_ sky130_fd_sc_hd__and3_1
X_2096_ clknet_4_8_0_sys_clk _0000_ VGND VGND VPWR VPWR pfd_inst.state\[0\] sky130_fd_sc_hd__dfxtp_1
X_1116_ _0510_ _0518_ _0517_ VGND VGND VPWR VPWR _0521_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_0_126 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2165_ clknet_4_7_0_sys_clk _0096_ VGND VGND VPWR VPWR net72 sky130_fd_sc_hd__dfxtp_1
X_1949_ _0381_ _0382_ _0380_ VGND VGND VPWR VPWR _0383_ sky130_fd_sc_hd__a21oi_1
XFILLER_21_211 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_21_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_21_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_29_355 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_29_322 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_28_88 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_44_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_44_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_14_217 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_5_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_12_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_22_261 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_13_Right_13 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1803_ lf_inst.zero_error_count\[1\] _0256_ net116 _0259_ VGND VGND VPWR VPWR _0260_
+ sky130_fd_sc_hd__a22o_1
XPHY_EDGE_ROW_22_Right_22 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1734_ _0202_ _0203_ _0204_ VGND VGND VPWR VPWR _0206_ sky130_fd_sc_hd__or3_1
X_1665_ lf_inst.integrator\[16\] lf_inst.integrator\[17\] net190 VGND VGND VPWR VPWR
+ _1029_ sky130_fd_sc_hd__o21ai_1
X_1596_ net226 net64 VGND VGND VPWR VPWR _0969_ sky130_fd_sc_hd__and2_1
XFILLER_7_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_7_292 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_38_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_31_Right_31 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_53_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2148_ clknet_4_12_0_sys_clk net339 VGND VGND VPWR VPWR lf_inst.zero_error_count\[1\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_26_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2079_ clknet_4_7_0_sys_clk _0020_ VGND VGND VPWR VPWR dco_inst.accumulator\[16\]
+ sky130_fd_sc_hd__dfxtp_1
XPHY_EDGE_ROW_40_Right_40 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_30_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_39_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_55_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_44_100 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_29_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_40_350 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_32_317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1450_ _0827_ _0828_ _0830_ _0832_ VGND VGND VPWR VPWR _0833_ sky130_fd_sc_hd__and4_1
X_1381_ _0663_ _0763_ VGND VGND VPWR VPWR _0764_ sky130_fd_sc_hd__nor2_1
X_2002_ _0220_ net131 VGND VGND VPWR VPWR _0428_ sky130_fd_sc_hd__or2_1
XFILLER_35_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1717_ _0161_ _0168_ _0189_ VGND VGND VPWR VPWR _0191_ sky130_fd_sc_hd__and3_1
X_1648_ _1012_ _1013_ VGND VGND VPWR VPWR _1014_ sky130_fd_sc_hd__nand2_1
X_1579_ net59 net341 net244 VGND VGND VPWR VPWR _0040_ sky130_fd_sc_hd__mux2_1
XFILLER_41_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_26_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_49_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_2_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_47_415 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_17_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_20_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1502_ _0821_ _0884_ VGND VGND VPWR VPWR _0885_ sky130_fd_sc_hd__nand2b_1
X_1433_ div_inst.counter\[11\] div_inst.counter\[10\] VGND VGND VPWR VPWR _0816_ sky130_fd_sc_hd__and2_1
X_1295_ net24 net22 net268 _0676_ VGND VGND VPWR VPWR _0678_ sky130_fd_sc_hd__or4_1
X_1364_ div_inst.counter\[12\] _0745_ VGND VGND VPWR VPWR _0747_ sky130_fd_sc_hd__nand2_1
XFILLER_23_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_23_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_54_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xinput19 div_val[26] VGND VGND VPWR VPWR net19 sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_52_440 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_10_342 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_14_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_6_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_9_184 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1080_ _0482_ _0486_ _0489_ VGND VGND VPWR VPWR _0490_ sky130_fd_sc_hd__o21ai_1
XFILLER_60_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_60_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1982_ net258 net49 net334 _0968_ _0411_ VGND VGND VPWR VPWR _0106_ sky130_fd_sc_hd__o221a_1
XFILLER_20_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_9_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_13_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1416_ _0694_ _0697_ _0707_ _0798_ _0705_ VGND VGND VPWR VPWR _0799_ sky130_fd_sc_hd__o221ai_1
X_1347_ div_inst.counter\[18\] net115 _0723_ VGND VGND VPWR VPWR _0730_ sky130_fd_sc_hd__and3_1
XFILLER_3_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_36_272 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_28_239 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1278_ net265 _0660_ VGND VGND VPWR VPWR _0661_ sky130_fd_sc_hd__nor2_1
XFILLER_51_297 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_3_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_47_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xfanout196 net200 VGND VGND VPWR VPWR net196 sky130_fd_sc_hd__clkbuf_2
Xfanout130 _0365_ VGND VGND VPWR VPWR net130 sky130_fd_sc_hd__buf_1
Xfanout163 net164 VGND VGND VPWR VPWR net163 sky130_fd_sc_hd__buf_1
Xfanout174 net183 VGND VGND VPWR VPWR net174 sky130_fd_sc_hd__clkbuf_2
Xfanout185 net187 VGND VGND VPWR VPWR net185 sky130_fd_sc_hd__buf_6
Xfanout141 _0240_ VGND VGND VPWR VPWR net141 sky130_fd_sc_hd__buf_1
XTAP_TAPCELL_ROW_6_165 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout152 net153 VGND VGND VPWR VPWR net152 sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_8_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_6_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_10_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1201_ dco_inst.accumulator\[22\] net81 VGND VGND VPWR VPWR _0594_ sky130_fd_sc_hd__nand2_1
X_2181_ clknet_4_10_0_sys_clk _0112_ VGND VGND VPWR VPWR net90 sky130_fd_sc_hd__dfxtp_1
X_1132_ _0531_ _0534_ VGND VGND VPWR VPWR _0535_ sky130_fd_sc_hd__xor2_1
X_1063_ _0475_ net243 _0474_ VGND VGND VPWR VPWR _0006_ sky130_fd_sc_hd__and3b_1
X_1965_ _0394_ _0396_ VGND VGND VPWR VPWR _0397_ sky130_fd_sc_hd__and2_1
X_1896_ _0992_ _0336_ VGND VGND VPWR VPWR _0337_ sky130_fd_sc_hd__xor2_1
XFILLER_56_345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_3_146 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_17_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_33_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_58_64 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_3_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_3_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold8 pfd_inst.fb_sync\[1\] VGND VGND VPWR VPWR net283 sky130_fd_sc_hd__dlygate4sd3_1
X_1750_ _0216_ _0218_ VGND VGND VPWR VPWR _0220_ sky130_fd_sc_hd__xnor2_1
XFILLER_30_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_25_281 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1681_ net196 lf_inst.integrator\[20\] VGND VGND VPWR VPWR _0159_ sky130_fd_sc_hd__nor2_1
Xmax_cap116 _0257_ VGND VGND VPWR VPWR net116 sky130_fd_sc_hd__buf_1
XFILLER_38_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2164_ clknet_4_5_0_sys_clk _0095_ VGND VGND VPWR VPWR net71 sky130_fd_sc_hd__dfxtp_1
XFILLER_53_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2095_ net216 _0036_ VGND VGND VPWR VPWR div_inst.clk_out sky130_fd_sc_hd__dfxtp_1
X_1046_ pfd_inst.ref_sync\[1\] _0454_ pfd_inst.state\[0\] pfd_inst.state\[2\] VGND
+ VGND VPWR VPWR _0464_ sky130_fd_sc_hd__a31o_1
X_1115_ _0506_ _0509_ _0511_ VGND VGND VPWR VPWR _0520_ sky130_fd_sc_hd__or3_1
XTAP_TAPCELL_ROW_0_127 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1948_ _0367_ _0368_ _0375_ _0373_ VGND VGND VPWR VPWR _0382_ sky130_fd_sc_hd__or4b_4
X_1879_ net167 _0322_ VGND VGND VPWR VPWR _0323_ sky130_fd_sc_hd__nor2_1
XFILLER_0_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_56_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_56_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_39_362 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_29_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_28_34 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_44_88 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_8_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_60_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_60_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_5_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_8_238 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_22_262 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_50_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_47_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xclkbuf_4_11_0_sys_clk clknet_0_sys_clk VGND VGND VPWR VPWR clknet_4_11_0_sys_clk
+ sky130_fd_sc_hd__clkbuf_8
XTAP_TAPCELL_ROW_45_398 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1733_ _0203_ _0204_ _0202_ VGND VGND VPWR VPWR _0205_ sky130_fd_sc_hd__o21ai_1
X_1802_ lf_inst.zero_error_count\[1\] lf_inst.zero_error_count\[0\] VGND VGND VPWR
+ VPWR _0259_ sky130_fd_sc_hd__nand2_1
X_1664_ _1010_ _1011_ _1014_ _1020_ VGND VGND VPWR VPWR _1028_ sky130_fd_sc_hd__a211o_1
X_1595_ net227 net206 VGND VGND VPWR VPWR _0968_ sky130_fd_sc_hd__or2_1
XFILLER_38_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2147_ clknet_4_9_0_sys_clk _0078_ VGND VGND VPWR VPWR lf_inst.zero_error_count\[0\]
+ sky130_fd_sc_hd__dfxtp_1
X_2216_ net209 VGND VGND VPWR VPWR net67 sky130_fd_sc_hd__clkbuf_1
XFILLER_26_348 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2078_ clknet_4_7_0_sys_clk _0019_ VGND VGND VPWR VPWR dco_inst.accumulator\[15\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_39_11 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_44_112 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_40_340 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1380_ net30 _0662_ VGND VGND VPWR VPWR _0763_ sky130_fd_sc_hd__and2_1
X_2001_ _0425_ _0421_ _0410_ _0426_ VGND VGND VPWR VPWR _0427_ sky130_fd_sc_hd__o31a_1
X_1716_ _0189_ VGND VGND VPWR VPWR _0190_ sky130_fd_sc_hd__inv_2
X_1647_ net189 lf_inst.integrator\[16\] VGND VGND VPWR VPWR _1013_ sky130_fd_sc_hd__nand2_1
X_1578_ net244 net289 _0957_ VGND VGND VPWR VPWR _0039_ sky130_fd_sc_hd__a21o_1
XFILLER_26_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_14_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_38_Left_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_9_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_55_460 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_17_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_15_90 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1501_ div_inst.counter\[14\] net118 _0818_ div_inst.counter\[15\] VGND VGND VPWR
+ VPWR _0884_ sky130_fd_sc_hd__a31o_1
X_1363_ net118 _0741_ _0745_ div_inst.counter\[12\] VGND VGND VPWR VPWR _0746_ sky130_fd_sc_hd__o22a_1
X_1432_ _0813_ _0814_ VGND VGND VPWR VPWR _0815_ sky130_fd_sc_hd__and2_1
X_1294_ net22 net268 _0676_ VGND VGND VPWR VPWR _0677_ sky130_fd_sc_hd__or3_1
XFILLER_31_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_54_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_52_441 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_39_292 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_36_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_36_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_10_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_10_354 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_9_185 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1981_ _0408_ _0409_ net178 VGND VGND VPWR VPWR _0411_ sky130_fd_sc_hd__o21ai_1
X_1415_ _0793_ _0797_ _0733_ _0735_ VGND VGND VPWR VPWR _0798_ sky130_fd_sc_hd__o211a_1
X_1346_ div_inst.counter\[16\] _0728_ _0727_ VGND VGND VPWR VPWR _0729_ sky130_fd_sc_hd__o21a_1
XFILLER_3_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_36_284 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1277_ net1 net12 net26 net267 VGND VGND VPWR VPWR _0660_ sky130_fd_sc_hd__or4_1
XFILLER_51_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xfanout131 _0365_ VGND VGND VPWR VPWR net131 sky130_fd_sc_hd__dlymetal6s2s_1
Xfanout120 div_inst.counter\[4\] VGND VGND VPWR VPWR net120 sky130_fd_sc_hd__buf_1
Xfanout175 net177 VGND VGND VPWR VPWR net175 sky130_fd_sc_hd__dlymetal6s2s_1
Xfanout197 net200 VGND VGND VPWR VPWR net197 sky130_fd_sc_hd__clkbuf_1
Xfanout164 net165 VGND VGND VPWR VPWR net164 sky130_fd_sc_hd__clkbuf_1
XFILLER_27_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout153 net154 VGND VGND VPWR VPWR net153 sky130_fd_sc_hd__clkbuf_1
Xfanout142 _0971_ VGND VGND VPWR VPWR net142 sky130_fd_sc_hd__clkbuf_2
XTAP_TAPCELL_ROW_6_166 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_8_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_6_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2180_ clknet_4_10_0_sys_clk _0111_ VGND VGND VPWR VPWR net88 sky130_fd_sc_hd__dfxtp_1
X_1200_ dco_inst.accumulator\[22\] net81 VGND VGND VPWR VPWR _0593_ sky130_fd_sc_hd__or2_1
XFILLER_26_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_25_Left_86 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1131_ _0532_ _0533_ VGND VGND VPWR VPWR _0534_ sky130_fd_sc_hd__and2b_1
X_1062_ _0471_ _0472_ _0473_ VGND VGND VPWR VPWR _0475_ sky130_fd_sc_hd__and3_1
XFILLER_18_240 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1964_ _0378_ _0383_ _0386_ _0387_ VGND VGND VPWR VPWR _0396_ sky130_fd_sc_hd__o31a_1
X_1895_ net208 _0961_ net138 VGND VGND VPWR VPWR _0336_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_56_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1329_ net117 _0710_ _0709_ VGND VGND VPWR VPWR _0712_ sky130_fd_sc_hd__o21ai_1
XTAP_TAPCELL_ROW_3_147 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_17_14 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_33_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_17_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_58_98 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold9 pfd_inst.ref_sync\[1\] VGND VGND VPWR VPWR net284 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_47_346 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_30_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_30_224 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_25_282 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_15_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1680_ net286 net160 _0158_ VGND VGND VPWR VPWR _0056_ sky130_fd_sc_hd__a21o_1
X_1114_ dco_inst.accumulator\[8\] net97 _0510_ _0511_ VGND VGND VPWR VPWR _0519_ sky130_fd_sc_hd__a31o_1
X_2163_ clknet_4_4_0_sys_clk _0094_ VGND VGND VPWR VPWR net70 sky130_fd_sc_hd__dfxtp_1
X_2094_ clknet_4_10_0_sys_clk _0035_ VGND VGND VPWR VPWR net100 sky130_fd_sc_hd__dfxtp_1
X_1045_ net284 _0454_ _0460_ _0463_ VGND VGND VPWR VPWR _0000_ sky130_fd_sc_hd__a31o_1
XTAP_TAPCELL_ROW_0_128 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1947_ _0367_ _0369_ _0375_ _0373_ _0366_ VGND VGND VPWR VPWR _0381_ sky130_fd_sc_hd__o311a_1
XFILLER_9_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1878_ _0315_ _0318_ _0320_ VGND VGND VPWR VPWR _0322_ sky130_fd_sc_hd__o21a_1
XTAP_TAPCELL_ROW_39_363 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_28_46 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_22_263 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_5_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_47_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_35_305 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_45_399 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1732_ lf_inst.integrator\[24\] lf_inst.integrator\[25\] net199 VGND VGND VPWR VPWR
+ _0204_ sky130_fd_sc_hd__o21a_1
X_1801_ net254 _0258_ VGND VGND VPWR VPWR _0078_ sky130_fd_sc_hd__and2_1
X_1663_ _1025_ _1026_ VGND VGND VPWR VPWR _1027_ sky130_fd_sc_hd__nand2_1
Xclkbuf_4_15_0_sys_clk clknet_0_sys_clk VGND VGND VPWR VPWR clknet_4_15_0_sys_clk
+ sky130_fd_sc_hd__clkbuf_8
X_1594_ net227 net206 VGND VGND VPWR VPWR _0967_ sky130_fd_sc_hd__nor2_1
XPHY_EDGE_ROW_7_Right_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2146_ clknet_4_9_0_sys_clk _0077_ VGND VGND VPWR VPWR lf_inst.error_in\[1\] sky130_fd_sc_hd__dfxtp_2
XTAP_TAPCELL_ROW_36_344 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_26_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2215_ clknet_4_3_0_sys_clk _0146_ VGND VGND VPWR VPWR net99 sky130_fd_sc_hd__dfxtp_1
X_2077_ clknet_4_5_0_sys_clk _0018_ VGND VGND VPWR VPWR dco_inst.accumulator\[14\]
+ sky130_fd_sc_hd__dfxtp_1
XPHY_EDGE_ROW_12_Left_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_39_23 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_29_198 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_58_480 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2000_ _0212_ net133 _0405_ _0413_ _0417_ VGND VGND VPWR VPWR _0426_ sky130_fd_sc_hd__a2111oi_1
XFILLER_35_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_31_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1715_ _0175_ _0182_ VGND VGND VPWR VPWR _0189_ sky130_fd_sc_hd__and2_1
X_1646_ net189 lf_inst.integrator\[16\] VGND VGND VPWR VPWR _1012_ sky130_fd_sc_hd__or2_1
X_1577_ net225 net58 VGND VGND VPWR VPWR _0957_ sky130_fd_sc_hd__and2_1
X_2129_ clknet_4_8_0_sys_clk _0067_ VGND VGND VPWR VPWR lf_inst.integrator\[30\] sky130_fd_sc_hd__dfxtp_1
XFILLER_25_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_41_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_41_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_57_260 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_49_249 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_1_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_17_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_55_461 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_9_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_13_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1500_ _0860_ _0862_ _0880_ _0882_ VGND VGND VPWR VPWR _0883_ sky130_fd_sc_hd__a22o_1
Xoutput90 net90 VGND VGND VPWR VPWR debug_dco_word[30] sky130_fd_sc_hd__buf_2
X_1293_ net269 net272 net274 net112 VGND VGND VPWR VPWR _0676_ sky130_fd_sc_hd__or4_2
X_1362_ _0666_ _0744_ VGND VGND VPWR VPWR _0745_ sky130_fd_sc_hd__and2_1
X_1431_ div_inst.counter\[9\] div_inst.counter\[8\] VGND VGND VPWR VPWR _0814_ sky130_fd_sc_hd__and2_1
X_1629_ _0995_ _0996_ VGND VGND VPWR VPWR _0997_ sky130_fd_sc_hd__and2b_1
XFILLER_36_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_52_442 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_52_56 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_52_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_14_127 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_52_67 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_10_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_22_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_9_186 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_60_211 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_60_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1980_ _0404_ _0403_ _0407_ VGND VGND VPWR VPWR _0410_ sky130_fd_sc_hd__a21o_1
XFILLER_54_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xrebuffer1 net140 VGND VGND VPWR VPWR net191 sky130_fd_sc_hd__dlygate4sd1_1
X_1414_ _0712_ _0720_ _0796_ VGND VGND VPWR VPWR _0797_ sky130_fd_sc_hd__or3_1
X_1345_ net241 _0668_ VGND VGND VPWR VPWR _0728_ sky130_fd_sc_hd__xor2_1
X_1276_ net1 net12 VGND VGND VPWR VPWR _0659_ sky130_fd_sc_hd__or2_1
XFILLER_51_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_22_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_59_311 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout110 net111 VGND VGND VPWR VPWR net110 sky130_fd_sc_hd__buf_1
Xfanout165 _0967_ VGND VGND VPWR VPWR net165 sky130_fd_sc_hd__buf_1
Xfanout143 _0971_ VGND VGND VPWR VPWR net143 sky130_fd_sc_hd__clkbuf_1
Xfanout132 _0364_ VGND VGND VPWR VPWR net132 sky130_fd_sc_hd__clkbuf_2
XTAP_TAPCELL_ROW_6_167 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout121 div_inst.counter\[2\] VGND VGND VPWR VPWR net121 sky130_fd_sc_hd__buf_1
Xfanout154 net155 VGND VGND VPWR VPWR net154 sky130_fd_sc_hd__buf_1
Xfanout176 net177 VGND VGND VPWR VPWR net176 sky130_fd_sc_hd__clkbuf_1
Xfanout198 net199 VGND VGND VPWR VPWR net198 sky130_fd_sc_hd__clkbuf_2
XFILLER_42_200 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout187 lf_inst.error_in\[1\] VGND VGND VPWR VPWR net187 sky130_fd_sc_hd__buf_6
XFILLER_10_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_6_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_0_Left_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1130_ dco_inst.accumulator\[12\] net70 VGND VGND VPWR VPWR _0533_ sky130_fd_sc_hd__nand2_1
XFILLER_19_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_33_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_33_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_33_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1061_ _0471_ _0472_ _0473_ VGND VGND VPWR VPWR _0474_ sky130_fd_sc_hd__a21o_1
XFILLER_18_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1963_ _0165_ _0170_ net126 VGND VGND VPWR VPWR _0395_ sky130_fd_sc_hd__a21o_1
X_1894_ net332 net151 _0333_ _0335_ _0988_ VGND VGND VPWR VPWR _0094_ sky130_fd_sc_hd__a221o_1
X_1259_ _0644_ VGND VGND VPWR VPWR _0645_ sky130_fd_sc_hd__inv_2
X_1328_ net117 _0710_ _0709_ VGND VGND VPWR VPWR _0711_ sky130_fd_sc_hd__o21a_1
XTAP_TAPCELL_ROW_3_148 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_17_26 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_59_174 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_47_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_15_200 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_25_283 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_15_299 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_23_91 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2093_ clknet_4_10_0_sys_clk _0034_ VGND VGND VPWR VPWR dco_inst.accumulator\[30\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_38_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1044_ pfd_inst.state\[0\] _0459_ _0461_ _0462_ VGND VGND VPWR VPWR _0463_ sky130_fd_sc_hd__a31o_1
X_1113_ _0505_ _0507_ _0512_ VGND VGND VPWR VPWR _0518_ sky130_fd_sc_hd__nand3_1
XTAP_TAPCELL_ROW_0_129 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2162_ clknet_4_5_0_sys_clk _0093_ VGND VGND VPWR VPWR net69 sky130_fd_sc_hd__dfxtp_1
X_1946_ _0378_ _0379_ VGND VGND VPWR VPWR _0380_ sky130_fd_sc_hd__or2_1
XFILLER_9_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1877_ _0315_ _0318_ _0320_ VGND VGND VPWR VPWR _0321_ sky130_fd_sc_hd__or3_1
XFILLER_56_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_118 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_56_166 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_44_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_44_13 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_39_364 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_28_58 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_60_34 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_22_264 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_47_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_47_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_35_317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1800_ net116 _0256_ lf_inst.zero_error_count\[0\] VGND VGND VPWR VPWR _0258_ sky130_fd_sc_hd__mux2_1
XFILLER_34_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1731_ _0163_ _0193_ _0197_ _0188_ VGND VGND VPWR VPWR _0203_ sky130_fd_sc_hd__o211a_1
X_1662_ net189 lf_inst.integrator\[18\] VGND VGND VPWR VPWR _1026_ sky130_fd_sc_hd__nand2_1
X_2214_ net217 _0145_ VGND VGND VPWR VPWR div_inst.counter\[31\] sky130_fd_sc_hd__dfxtp_1
XFILLER_38_111 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1593_ _0963_ net166 VGND VGND VPWR VPWR _0966_ sky130_fd_sc_hd__nor2_1
XFILLER_53_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_36_345 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2145_ clknet_4_9_0_sys_clk _0076_ VGND VGND VPWR VPWR lf_inst.error_in\[0\] sky130_fd_sc_hd__dfxtp_1
Xclkbuf_0_sys_clk sys_clk VGND VGND VPWR VPWR clknet_0_sys_clk sky130_fd_sc_hd__clkbuf_16
X_2076_ clknet_4_5_0_sys_clk _0017_ VGND VGND VPWR VPWR dco_inst.accumulator\[13\]
+ sky130_fd_sc_hd__dfxtp_1
X_1929_ net224 net207 net187 VGND VGND VPWR VPWR _0365_ sky130_fd_sc_hd__a21bo_1
XFILLER_14_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_39_68 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_39_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_39_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_29_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_55_89 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_58_481 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_35_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_35_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_23_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_50_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_33_326 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1714_ _0187_ VGND VGND VPWR VPWR _0188_ sky130_fd_sc_hd__inv_2
XFILLER_6_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1576_ net55 net304 net244 VGND VGND VPWR VPWR _0038_ sky130_fd_sc_hd__mux2_1
X_1645_ _0997_ _0999_ _1004_ _1008_ VGND VGND VPWR VPWR _1011_ sky130_fd_sc_hd__a31oi_2
X_2059_ _0839_ net107 VGND VGND VPWR VPWR _0145_ sky130_fd_sc_hd__nor2_1
X_2128_ clknet_4_8_0_sys_clk _0066_ VGND VGND VPWR VPWR lf_inst.integrator\[29\] sky130_fd_sc_hd__dfxtp_1
XFILLER_34_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_41_14 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_49_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_57_294 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_57_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_17_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_55_462 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_40_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_32_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_9_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_56_7 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1430_ div_inst.counter\[5\] net120 _0809_ _0812_ VGND VGND VPWR VPWR _0813_ sky130_fd_sc_hd__and4_1
Xoutput91 net91 VGND VGND VPWR VPWR debug_dco_word[31] sky130_fd_sc_hd__buf_2
X_1292_ net272 net274 net112 VGND VGND VPWR VPWR _0675_ sky130_fd_sc_hd__or3_1
XFILLER_48_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xoutput80 net80 VGND VGND VPWR VPWR debug_dco_word[21] sky130_fd_sc_hd__buf_2
X_1361_ net4 _0665_ VGND VGND VPWR VPWR _0744_ sky130_fd_sc_hd__nand2_1
XFILLER_31_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_31_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1559_ net24 _0842_ _0844_ net22 VGND VGND VPWR VPWR _0942_ sky130_fd_sc_hd__a22o_1
X_1628_ net188 lf_inst.integrator\[14\] VGND VGND VPWR VPWR _0996_ sky130_fd_sc_hd__nand2_1
XFILLER_54_231 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_39_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_39_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_54_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_52_443 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_52_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_14_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_9_187 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_60_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_13_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xrebuffer2 net191 VGND VGND VPWR VPWR net202 sky130_fd_sc_hd__dlygate4sd1_1
XFILLER_20_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1413_ _0730_ _0731_ _0795_ _0725_ VGND VGND VPWR VPWR _0796_ sky130_fd_sc_hd__or4b_1
X_1275_ _0657_ _0658_ VGND VGND VPWR VPWR _0035_ sky130_fd_sc_hd__nor2_1
X_1344_ _0669_ _0726_ div_inst.counter\[17\] VGND VGND VPWR VPWR _0727_ sky130_fd_sc_hd__a21o_1
XFILLER_3_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_22_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_59_323 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout133 _0364_ VGND VGND VPWR VPWR net133 sky130_fd_sc_hd__buf_1
Xfanout177 net182 VGND VGND VPWR VPWR net177 sky130_fd_sc_hd__buf_1
Xfanout111 _0449_ VGND VGND VPWR VPWR net111 sky130_fd_sc_hd__buf_1
Xfanout199 net200 VGND VGND VPWR VPWR net199 sky130_fd_sc_hd__dlymetal6s2s_1
Xfanout144 net145 VGND VGND VPWR VPWR net144 sky130_fd_sc_hd__buf_1
XTAP_TAPCELL_ROW_6_168 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout122 div_inst.counter\[1\] VGND VGND VPWR VPWR net122 sky130_fd_sc_hd__dlymetal6s2s_1
Xfanout166 net167 VGND VGND VPWR VPWR net166 sky130_fd_sc_hd__dlymetal6s2s_1
Xfanout155 net165 VGND VGND VPWR VPWR net155 sky130_fd_sc_hd__buf_1
Xfanout188 net190 VGND VGND VPWR VPWR net188 sky130_fd_sc_hd__buf_6
XFILLER_47_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_42_212 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_29_Right_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_38_Right_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_8_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_12_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_47_Right_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1060_ dco_inst.accumulator\[0\] net210 _0468_ _0466_ VGND VGND VPWR VPWR _0473_
+ sky130_fd_sc_hd__a31o_1
XPHY_EDGE_ROW_56_Right_56 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1962_ _0391_ _0393_ VGND VGND VPWR VPWR _0394_ sky130_fd_sc_hd__nor2_1
XFILLER_18_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_18_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1893_ net167 _0334_ VGND VGND VPWR VPWR _0335_ sky130_fd_sc_hd__nor2_1
X_1258_ dco_inst.accumulator\[29\] net88 VGND VGND VPWR VPWR _0644_ sky130_fd_sc_hd__or2_1
X_1327_ net276 _0672_ VGND VGND VPWR VPWR _0710_ sky130_fd_sc_hd__xor2_1
X_1189_ _0544_ _0556_ _0557_ _0568_ _0581_ VGND VGND VPWR VPWR _0584_ sky130_fd_sc_hd__o2111ai_4
XTAP_TAPCELL_ROW_3_149 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_17_38 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_33_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_3_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_59_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_47_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_30_204 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_31_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_2_171 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2092_ clknet_4_11_0_sys_clk _0033_ VGND VGND VPWR VPWR dco_inst.accumulator\[29\]
+ sky130_fd_sc_hd__dfxtp_1
X_1043_ pfd_inst.state\[2\] _0458_ net236 VGND VGND VPWR VPWR _0462_ sky130_fd_sc_hd__a21o_1
XFILLER_0_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1112_ _0515_ _0516_ VGND VGND VPWR VPWR _0517_ sky130_fd_sc_hd__nand2_1
X_2161_ clknet_4_4_0_sys_clk _0092_ VGND VGND VPWR VPWR net68 sky130_fd_sc_hd__dfxtp_1
X_1945_ _0165_ net125 VGND VGND VPWR VPWR _0379_ sky130_fd_sc_hd__and2_1
X_1876_ _0975_ net139 VGND VGND VPWR VPWR _0320_ sky130_fd_sc_hd__xnor2_1
XFILLER_56_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_29_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_28_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_56_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_52_351 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_52_340 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_44_329 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_39_365 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_12_226 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_60_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_60_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_20_270 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_22_265 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_35_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_18_92 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_13_210 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1730_ net194 lf_inst.integrator\[26\] VGND VGND VPWR VPWR _0202_ sky130_fd_sc_hd__xor2_1
X_1661_ net189 lf_inst.integrator\[18\] VGND VGND VPWR VPWR _1025_ sky130_fd_sc_hd__or2_1
X_1592_ net248 net206 VGND VGND VPWR VPWR _0965_ sky130_fd_sc_hd__nand2_1
X_2213_ net216 _0144_ VGND VGND VPWR VPWR div_inst.counter\[30\] sky130_fd_sc_hd__dfxtp_1
XFILLER_38_123 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2144_ clknet_4_6_0_sys_clk net248 VGND VGND VPWR VPWR lf_inst.sample_en sky130_fd_sc_hd__dfxtp_1
XPHY_EDGE_ROW_46_Left_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_36_346 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2075_ clknet_4_5_0_sys_clk _0016_ VGND VGND VPWR VPWR dco_inst.accumulator\[12\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_30_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1928_ net224 net207 net185 VGND VGND VPWR VPWR _0364_ sky130_fd_sc_hd__a21boi_2
X_1859_ _0293_ _0296_ _0302_ VGND VGND VPWR VPWR _0305_ sky130_fd_sc_hd__or3b_4
XPHY_EDGE_ROW_55_Left_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_44_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_29_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_29_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_17_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_52_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_52_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_20_60 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_33_327 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1713_ net196 lf_inst.integrator\[24\] VGND VGND VPWR VPWR _0187_ sky130_fd_sc_hd__xnor2_1
X_1575_ net44 net305 net246 VGND VGND VPWR VPWR _0037_ sky130_fd_sc_hd__mux2_1
X_1644_ _1009_ _0985_ _0979_ VGND VGND VPWR VPWR _1010_ sky130_fd_sc_hd__or3_4
X_2127_ clknet_4_11_0_sys_clk _0065_ VGND VGND VPWR VPWR lf_inst.integrator\[28\]
+ sky130_fd_sc_hd__dfxtp_1
X_2058_ _0837_ net106 VGND VGND VPWR VPWR _0144_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_55_463 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_17_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_30_308 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_13_354 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1360_ div_inst.counter\[15\] _0737_ VGND VGND VPWR VPWR _0743_ sky130_fd_sc_hd__and2_1
Xoutput70 net70 VGND VGND VPWR VPWR debug_dco_word[12] sky130_fd_sc_hd__buf_2
Xoutput81 net81 VGND VGND VPWR VPWR debug_dco_word[22] sky130_fd_sc_hd__buf_2
X_1291_ net17 net16 net276 _0672_ VGND VGND VPWR VPWR _0674_ sky130_fd_sc_hd__or4_1
Xoutput92 net92 VGND VGND VPWR VPWR debug_dco_word[3] sky130_fd_sc_hd__buf_2
X_1558_ net22 _0844_ _0843_ VGND VGND VPWR VPWR _0941_ sky130_fd_sc_hd__o21ai_1
X_1489_ div_inst.counter\[16\] _0821_ div_inst.counter\[17\] VGND VGND VPWR VPWR _0872_
+ sky130_fd_sc_hd__a21oi_1
X_1627_ net188 lf_inst.integrator\[14\] VGND VGND VPWR VPWR _0995_ sky130_fd_sc_hd__nor2_1
XFILLER_54_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_36_48 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_52_444 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_22_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_7_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_60_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_45_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_26_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xrebuffer3 lf_inst.error_in\[1\] VGND VGND VPWR VPWR net278 sky130_fd_sc_hd__dlygate4sd1_1
X_1412_ _0722_ _0729_ _0794_ VGND VGND VPWR VPWR _0795_ sky130_fd_sc_hd__nand3_1
X_1343_ net241 _0668_ net9 VGND VGND VPWR VPWR _0726_ sky130_fd_sc_hd__o21ai_1
X_1274_ _0650_ _0654_ _0656_ net233 VGND VGND VPWR VPWR _0658_ sky130_fd_sc_hd__a31o_1
XFILLER_51_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_36_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_59_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_59_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout112 _0674_ VGND VGND VPWR VPWR net112 sky130_fd_sc_hd__buf_1
Xfanout156 net158 VGND VGND VPWR VPWR net156 sky130_fd_sc_hd__dlymetal6s2s_1
Xfanout178 net181 VGND VGND VPWR VPWR net178 sky130_fd_sc_hd__dlymetal6s2s_1
Xfanout189 net190 VGND VGND VPWR VPWR net189 sky130_fd_sc_hd__buf_1
XTAP_TAPCELL_ROW_6_169 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout123 div_inst.counter\[0\] VGND VGND VPWR VPWR net123 sky130_fd_sc_hd__buf_1
Xfanout167 net168 VGND VGND VPWR VPWR net167 sky130_fd_sc_hd__dlymetal6s2s_1
Xfanout134 _0272_ VGND VGND VPWR VPWR net134 sky130_fd_sc_hd__buf_2
Xfanout145 net146 VGND VGND VPWR VPWR net145 sky130_fd_sc_hd__buf_4
Xfanout101 net105 VGND VGND VPWR VPWR net101 sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_2_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_53_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1961_ _0179_ net132 VGND VGND VPWR VPWR _0393_ sky130_fd_sc_hd__nor2_1
XFILLER_33_268 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_33_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1892_ _0328_ _0332_ VGND VGND VPWR VPWR _0334_ sky130_fd_sc_hd__and2_1
X_1326_ _0673_ _0708_ div_inst.counter\[23\] VGND VGND VPWR VPWR _0709_ sky130_fd_sc_hd__a21o_1
X_1257_ _0643_ _0642_ VGND VGND VPWR VPWR _0032_ sky130_fd_sc_hd__and2b_1
X_1188_ _0566_ _0573_ _0574_ _0582_ VGND VGND VPWR VPWR _0583_ sky130_fd_sc_hd__o211a_1
XFILLER_30_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_2_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2160_ clknet_4_4_0_sys_clk _0091_ VGND VGND VPWR VPWR net98 sky130_fd_sc_hd__dfxtp_1
X_2091_ clknet_4_11_0_sys_clk _0032_ VGND VGND VPWR VPWR dco_inst.accumulator\[28\]
+ sky130_fd_sc_hd__dfxtp_1
X_1042_ net254 _0460_ _0461_ VGND VGND VPWR VPWR _0001_ sky130_fd_sc_hd__and3_1
XFILLER_0_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1111_ dco_inst.accumulator\[10\] net68 VGND VGND VPWR VPWR _0516_ sky130_fd_sc_hd__nand2_1
X_1944_ _0165_ net125 VGND VGND VPWR VPWR _0378_ sky130_fd_sc_hd__nor2_1
X_1875_ net184 net151 _0319_ net172 _0969_ VGND VGND VPWR VPWR _0091_ sky130_fd_sc_hd__a221o_1
XFILLER_9_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_56_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1309_ net272 net274 net112 net269 VGND VGND VPWR VPWR _0692_ sky130_fd_sc_hd__o31a_1
XTAP_TAPCELL_ROW_39_366 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_12_238 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_60_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_20_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_47_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_47_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_18_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_13_211 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1660_ net321 net160 _1023_ net180 _1024_ VGND VGND VPWR VPWR _0054_ sky130_fd_sc_hd__a221o_1
X_1591_ net248 net205 VGND VGND VPWR VPWR _0964_ sky130_fd_sc_hd__and2_1
XFILLER_7_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_7_297 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2212_ net221 _0143_ VGND VGND VPWR VPWR div_inst.counter\[29\] sky130_fd_sc_hd__dfxtp_1
X_2143_ clknet_4_8_0_sys_clk net283 net253 VGND VGND VPWR VPWR pfd_inst.fb_sync\[2\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_38_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_53_127 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_36_347 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2074_ clknet_4_5_0_sys_clk _0015_ VGND VGND VPWR VPWR dco_inst.accumulator\[11\]
+ sky130_fd_sc_hd__dfxtp_1
X_1927_ net317 net153 _0363_ net180 _1024_ VGND VGND VPWR VPWR _0099_ sky130_fd_sc_hd__a221o_1
X_1858_ net306 net149 _0304_ net174 _0960_ VGND VGND VPWR VPWR _0089_ sky130_fd_sc_hd__a221o_1
XFILLER_39_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1789_ unlock_timer\[1\] unlock_timer\[0\] _0249_ unlock_timer\[5\] VGND VGND VPWR
+ VPWR _0250_ sky130_fd_sc_hd__a31o_1
XFILLER_44_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_29_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_212 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_20_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_29_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_33_328 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1712_ net311 net162 _0185_ _0186_ VGND VGND VPWR VPWR _0060_ sky130_fd_sc_hd__a211o_1
XFILLER_6_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1643_ _0990_ _0984_ _0997_ _1004_ VGND VGND VPWR VPWR _1009_ sky130_fd_sc_hd__or4bb_4
X_1574_ _0807_ _0956_ net252 VGND VGND VPWR VPWR _0036_ sky130_fd_sc_hd__o21a_1
XFILLER_6_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2057_ _0842_ net109 VGND VGND VPWR VPWR _0143_ sky130_fd_sc_hd__nor2_1
X_2126_ clknet_4_11_0_sys_clk _0064_ VGND VGND VPWR VPWR lf_inst.integrator\[27\]
+ sky130_fd_sc_hd__dfxtp_1
XPHY_EDGE_ROW_16_Left_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_41_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_1_204 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_57_230 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_25_182 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_17_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_17_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_40_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_30_309 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_9_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_15_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xoutput82 net82 VGND VGND VPWR VPWR debug_dco_word[23] sky130_fd_sc_hd__buf_2
Xoutput93 net93 VGND VGND VPWR VPWR debug_dco_word[4] sky130_fd_sc_hd__buf_2
Xoutput71 net71 VGND VGND VPWR VPWR debug_dco_word[13] sky130_fd_sc_hd__buf_2
XFILLER_48_263 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1290_ net16 net276 _0672_ VGND VGND VPWR VPWR _0673_ sky130_fd_sc_hd__or3_1
XFILLER_0_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1626_ lf_inst.integrator\[13\] net152 _0993_ _0994_ VGND VGND VPWR VPWR _0050_ sky130_fd_sc_hd__a211o_1
X_1557_ net25 _0837_ VGND VGND VPWR VPWR _0940_ sky130_fd_sc_hd__and2_1
X_1488_ net13 _0868_ _0870_ net277 VGND VGND VPWR VPWR _0871_ sky130_fd_sc_hd__a22oi_1
XFILLER_36_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2109_ clknet_4_1_0_sys_clk _0047_ VGND VGND VPWR VPWR lf_inst.integrator\[10\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_52_445 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_52_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_22_174 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_22_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_45_200 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_60_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_60_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_45_255 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_9_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_42_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xrebuffer4 _0970_ VGND VGND VPWR VPWR net279 sky130_fd_sc_hd__dlygate4sd1_1
X_1273_ _0650_ _0654_ _0656_ VGND VGND VPWR VPWR _0657_ sky130_fd_sc_hd__a21oi_1
X_1411_ div_inst.counter\[16\] _0728_ VGND VGND VPWR VPWR _0794_ sky130_fd_sc_hd__nand2_1
X_1342_ div_inst.counter\[19\] _0721_ _0724_ VGND VGND VPWR VPWR _0725_ sky130_fd_sc_hd__o21a_1
XFILLER_51_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_36_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_51_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_22_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1609_ lf_inst.integrator\[11\] net144 VGND VGND VPWR VPWR _0980_ sky130_fd_sc_hd__and2_1
Xfanout102 net105 VGND VGND VPWR VPWR net102 sky130_fd_sc_hd__buf_1
Xfanout157 net158 VGND VGND VPWR VPWR net157 sky130_fd_sc_hd__buf_1
Xfanout179 net181 VGND VGND VPWR VPWR net179 sky130_fd_sc_hd__buf_1
Xfanout124 div_inst.counter\[0\] VGND VGND VPWR VPWR net124 sky130_fd_sc_hd__buf_1
Xfanout135 _0272_ VGND VGND VPWR VPWR net135 sky130_fd_sc_hd__buf_1
Xfanout168 net171 VGND VGND VPWR VPWR net168 sky130_fd_sc_hd__clkbuf_1
Xfanout146 _0970_ VGND VGND VPWR VPWR net146 sky130_fd_sc_hd__buf_6
XFILLER_27_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_4_0_0_sys_clk clknet_0_sys_clk VGND VGND VPWR VPWR clknet_4_0_0_sys_clk sky130_fd_sc_hd__clkbuf_8
XPHY_EDGE_ROW_19_Left_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_10_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_2_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1960_ _0178_ net128 VGND VGND VPWR VPWR _0392_ sky130_fd_sc_hd__or2_1
X_1891_ _0328_ _0332_ VGND VGND VPWR VPWR _0333_ sky130_fd_sc_hd__or2_1
XTAP_TAPCELL_ROW_11_194 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_56_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1256_ _0638_ _0640_ _0641_ net235 VGND VGND VPWR VPWR _0643_ sky130_fd_sc_hd__a31o_1
X_1325_ net276 _0672_ net16 VGND VGND VPWR VPWR _0708_ sky130_fd_sc_hd__o21ai_1
X_1187_ _0569_ _0581_ VGND VGND VPWR VPWR _0582_ sky130_fd_sc_hd__nand2_1
XFILLER_24_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_24_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_59_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_47_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_2_140 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_4_Left_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_15_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_23_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2090_ clknet_4_11_0_sys_clk _0031_ VGND VGND VPWR VPWR dco_inst.accumulator\[27\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_38_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_2_184 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1110_ dco_inst.accumulator\[10\] net68 VGND VGND VPWR VPWR _0515_ sky130_fd_sc_hd__or2_1
XFILLER_17_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1041_ pfd_inst.ref_sync\[1\] _0454_ VGND VGND VPWR VPWR _0461_ sky130_fd_sc_hd__nand2_1
X_1943_ net316 net160 _0377_ net180 _0157_ VGND VGND VPWR VPWR _0101_ sky130_fd_sc_hd__a221o_1
X_1874_ _0314_ _0317_ VGND VGND VPWR VPWR _0319_ sky130_fd_sc_hd__xnor2_1
X_1239_ _0627_ VGND VGND VPWR VPWR _0628_ sky130_fd_sc_hd__inv_2
X_1308_ _0689_ _0690_ _0681_ _0685_ VGND VGND VPWR VPWR _0691_ sky130_fd_sc_hd__and4bb_1
XFILLER_44_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_39_367 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_60_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_44_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_20_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_47_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_47_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_7_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_50_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1590_ lf_inst.integrator\[9\] _0961_ VGND VGND VPWR VPWR _0963_ sky130_fd_sc_hd__xnor2_1
X_2211_ net220 _0142_ VGND VGND VPWR VPWR div_inst.counter\[28\] sky130_fd_sc_hd__dfxtp_1
XFILLER_53_139 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2142_ clknet_4_8_0_sys_clk net281 net253 VGND VGND VPWR VPWR pfd_inst.fb_sync\[1\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_26_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2073_ clknet_4_4_0_sys_clk _0014_ VGND VGND VPWR VPWR dco_inst.accumulator\[10\]
+ sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_44_392 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_348 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1926_ _0361_ _0362_ VGND VGND VPWR VPWR _0363_ sky130_fd_sc_hd__xor2_1
X_1857_ _0302_ _0303_ VGND VGND VPWR VPWR _0304_ sky130_fd_sc_hd__xnor2_1
X_1788_ unlock_timer\[4\] unlock_timer\[3\] unlock_timer\[2\] VGND VGND VPWR VPWR
+ _0249_ sky130_fd_sc_hd__and3_1
XFILLER_29_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_55_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_29_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_29_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold60 net94 VGND VGND VPWR VPWR net335 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_50_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_43_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_33_329 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_31_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_31_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_31_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1711_ net238 net48 VGND VGND VPWR VPWR _0186_ sky130_fd_sc_hd__and2_1
XFILLER_6_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1642_ lf_inst.integrator\[14\] lf_inst.integrator\[15\] net190 VGND VGND VPWR VPWR
+ _1008_ sky130_fd_sc_hd__o21a_1
XFILLER_58_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1573_ _0887_ _0947_ _0955_ _0951_ VGND VGND VPWR VPWR _0956_ sky130_fd_sc_hd__o31a_1
XFILLER_6_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2056_ _0844_ net109 VGND VGND VPWR VPWR _0142_ sky130_fd_sc_hd__nor2_1
X_2125_ clknet_4_11_0_sys_clk _0063_ VGND VGND VPWR VPWR lf_inst.integrator\[26\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_41_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_34_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_25_18 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_19_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1909_ _0340_ _0345_ _0347_ VGND VGND VPWR VPWR _0348_ sky130_fd_sc_hd__a21oi_1
XFILLER_22_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_49_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_32_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_25_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_9_316 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_40_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_9_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xoutput83 net83 VGND VGND VPWR VPWR debug_dco_word[24] sky130_fd_sc_hd__buf_2
XPHY_EDGE_ROW_33_Left_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xoutput94 net94 VGND VGND VPWR VPWR debug_dco_word[5] sky130_fd_sc_hd__buf_2
Xoutput72 net72 VGND VGND VPWR VPWR debug_dco_word[14] sky130_fd_sc_hd__buf_2
XFILLER_48_275 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1556_ net21 _0846_ VGND VGND VPWR VPWR _0939_ sky130_fd_sc_hd__nor2_1
X_1625_ net229 net37 VGND VGND VPWR VPWR _0994_ sky130_fd_sc_hd__and2_1
XFILLER_36_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1487_ div_inst.counter\[18\] net114 VGND VGND VPWR VPWR _0870_ sky130_fd_sc_hd__xnor2_1
X_2039_ _0894_ net103 VGND VGND VPWR VPWR _0125_ sky130_fd_sc_hd__nor2_1
X_2108_ clknet_4_1_0_sys_clk _0046_ VGND VGND VPWR VPWR lf_inst.integrator\[9\] sky130_fd_sc_hd__dfxtp_1
XFILLER_14_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_60_490 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_22_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_45_267 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_60_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_42_60 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_13_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_47_6 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_42_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1410_ _0749_ _0790_ _0792_ VGND VGND VPWR VPWR _0793_ sky130_fd_sc_hd__o21a_1
Xrebuffer5 _0984_ VGND VGND VPWR VPWR net280 sky130_fd_sc_hd__dlygate4sd1_1
X_1272_ net220 net91 VGND VGND VPWR VPWR _0656_ sky130_fd_sc_hd__xnor2_1
X_1341_ net115 _0723_ div_inst.counter\[18\] VGND VGND VPWR VPWR _0724_ sky130_fd_sc_hd__a21o_1
XFILLER_51_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_8_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_59_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout125 net126 VGND VGND VPWR VPWR net125 sky130_fd_sc_hd__buf_1
Xfanout103 net105 VGND VGND VPWR VPWR net103 sky130_fd_sc_hd__dlymetal6s2s_1
Xfanout114 _0823_ VGND VGND VPWR VPWR net114 sky130_fd_sc_hd__buf_1
Xfanout147 _0968_ VGND VGND VPWR VPWR net147 sky130_fd_sc_hd__clkbuf_2
Xfanout136 net137 VGND VGND VPWR VPWR net136 sky130_fd_sc_hd__buf_8
X_1608_ lf_inst.integrator\[11\] net144 VGND VGND VPWR VPWR _0979_ sky130_fd_sc_hd__nor2_1
X_1539_ net263 _0919_ _0921_ net29 VGND VGND VPWR VPWR _0922_ sky130_fd_sc_hd__o22a_1
Xfanout158 net159 VGND VGND VPWR VPWR net158 sky130_fd_sc_hd__clkbuf_2
Xfanout169 net171 VGND VGND VPWR VPWR net169 sky130_fd_sc_hd__clkbuf_2
XFILLER_27_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_42_226 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_27_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_12_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_12_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_4_4_0_sys_clk clknet_0_sys_clk VGND VGND VPWR VPWR clknet_4_4_0_sys_clk sky130_fd_sc_hd__clkbuf_8
XTAP_TAPCELL_ROW_5_160 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_2_333 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_16_Right_16 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_41_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_25_Right_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1890_ _0311_ _0324_ _0329_ _0331_ VGND VGND VPWR VPWR _0332_ sky130_fd_sc_hd__a31o_1
XTAP_TAPCELL_ROW_11_195 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1255_ _0640_ _0641_ _0638_ VGND VGND VPWR VPWR _0642_ sky130_fd_sc_hd__a21o_1
X_1324_ _0698_ _0699_ _0704_ _0706_ VGND VGND VPWR VPWR _0707_ sky130_fd_sc_hd__or4_1
XPHY_EDGE_ROW_34_Right_34 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1186_ _0567_ _0575_ VGND VGND VPWR VPWR _0581_ sky130_fd_sc_hd__nor2_1
XFILLER_33_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_24_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_24_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_20_Left_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_43_Right_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_59_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_58_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_52_Right_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_47_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_2_141 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_23_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_48_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_48_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1040_ pfd_inst.state\[0\] _0458_ pfd_inst.state\[1\] VGND VGND VPWR VPWR _0460_
+ sky130_fd_sc_hd__a21o_1
X_1942_ _0372_ _0376_ VGND VGND VPWR VPWR _0377_ sky130_fd_sc_hd__xnor2_1
X_1873_ _0314_ _0316_ VGND VGND VPWR VPWR _0318_ sky130_fd_sc_hd__nor2_1
XFILLER_28_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1238_ _0607_ _0618_ _0617_ VGND VGND VPWR VPWR _0627_ sky130_fd_sc_hd__a21boi_2
XFILLER_52_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1307_ div_inst.counter\[29\] _0683_ _0684_ div_inst.counter\[28\] VGND VGND VPWR
+ VPWR _0690_ sky130_fd_sc_hd__a22o_1
X_1169_ dco_inst.accumulator\[18\] net76 VGND VGND VPWR VPWR _0566_ sky130_fd_sc_hd__nand2_1
XFILLER_60_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_50_60 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_34_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_7_255 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_11_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_59_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2210_ net220 _0141_ VGND VGND VPWR VPWR div_inst.counter\[27\] sky130_fd_sc_hd__dfxtp_1
XFILLER_46_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2141_ clknet_4_8_0_sys_clk div_inst.clk_out net253 VGND VGND VPWR VPWR pfd_inst.fb_sync\[0\]
+ sky130_fd_sc_hd__dfrtp_1
XTAP_TAPCELL_ROW_36_349 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2072_ clknet_4_5_0_sys_clk _0013_ VGND VGND VPWR VPWR dco_inst.accumulator\[9\]
+ sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_44_393 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1925_ net143 _1017_ _0351_ _0356_ VGND VGND VPWR VPWR _0362_ sky130_fd_sc_hd__o22ai_1
X_1856_ lf_inst.integrator\[6\] net137 _0299_ VGND VGND VPWR VPWR _0303_ sky130_fd_sc_hd__a21oi_1
X_1787_ net285 _0246_ _0248_ VGND VGND VPWR VPWR _0074_ sky130_fd_sc_hd__a21oi_1
XFILLER_29_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_2_Right_2 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_44_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_4_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_42_Left_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_4_269 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_20_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_20_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_35_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_29_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xhold61 lf_inst.integrator\[7\] VGND VGND VPWR VPWR net336 sky130_fd_sc_hd__dlygate4sd3_1
Xhold50 net69 VGND VGND VPWR VPWR net325 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_16_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_51_Left_112 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_41_374 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_60_Left_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1710_ net170 _0184_ VGND VGND VPWR VPWR _0185_ sky130_fd_sc_hd__nor2_1
X_1572_ _0901_ _0915_ _0954_ _0890_ VGND VGND VPWR VPWR _0955_ sky130_fd_sc_hd__nand4b_1
XFILLER_6_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1641_ lf_inst.integrator\[15\] net152 _1006_ net173 _1007_ VGND VGND VPWR VPWR _0052_
+ sky130_fd_sc_hd__a221o_1
X_2124_ clknet_4_14_0_sys_clk _0062_ VGND VGND VPWR VPWR lf_inst.integrator\[25\]
+ sky130_fd_sc_hd__dfxtp_1
X_2055_ _0846_ net109 VGND VGND VPWR VPWR _0141_ sky130_fd_sc_hd__nor2_1
X_1839_ _0274_ _0277_ _0280_ _0273_ VGND VGND VPWR VPWR _0289_ sky130_fd_sc_hd__o211a_1
X_1908_ net146 _1006_ VGND VGND VPWR VPWR _0347_ sky130_fd_sc_hd__xnor2_1
XFILLER_1_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_9_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_13_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_13_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_15_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xoutput84 net84 VGND VGND VPWR VPWR debug_dco_word[25] sky130_fd_sc_hd__buf_2
XFILLER_0_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xoutput95 net95 VGND VGND VPWR VPWR debug_dco_word[6] sky130_fd_sc_hd__buf_2
Xoutput73 net73 VGND VGND VPWR VPWR debug_dco_word[15] sky130_fd_sc_hd__buf_2
XFILLER_48_287 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1624_ net167 _0992_ VGND VGND VPWR VPWR _0993_ sky130_fd_sc_hd__nor2_1
X_1555_ net124 net12 _0924_ VGND VGND VPWR VPWR _0938_ sky130_fd_sc_hd__a21oi_1
X_1486_ net14 _0865_ _0868_ net13 VGND VGND VPWR VPWR _0869_ sky130_fd_sc_hd__o22ai_1
XFILLER_39_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2107_ clknet_4_0_0_sys_clk _0045_ VGND VGND VPWR VPWR lf_inst.integrator\[0\] sky130_fd_sc_hd__dfxtp_1
X_2038_ _0898_ net104 VGND VGND VPWR VPWR _0124_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_60_491 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_6_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_60_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_26_40 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_9_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_9_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_13_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1340_ net10 _0669_ VGND VGND VPWR VPWR _0723_ sky130_fd_sc_hd__nand2_1
XFILLER_5_320 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1271_ _0652_ _0653_ _0655_ VGND VGND VPWR VPWR _0034_ sky130_fd_sc_hd__a21oi_1
XFILLER_3_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_8_180 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_51_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_51_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_59_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1469_ net272 _0851_ VGND VGND VPWR VPWR _0852_ sky130_fd_sc_hd__nor2_1
Xfanout115 _0670_ VGND VGND VPWR VPWR net115 sky130_fd_sc_hd__buf_1
Xfanout126 net127 VGND VGND VPWR VPWR net126 sky130_fd_sc_hd__clkbuf_1
Xfanout104 net105 VGND VGND VPWR VPWR net104 sky130_fd_sc_hd__clkbuf_1
Xfanout159 net164 VGND VGND VPWR VPWR net159 sky130_fd_sc_hd__buf_1
Xfanout148 net150 VGND VGND VPWR VPWR net148 sky130_fd_sc_hd__dlymetal6s2s_1
Xfanout137 net138 VGND VGND VPWR VPWR net137 sky130_fd_sc_hd__buf_8
X_1538_ _0810_ _0920_ VGND VGND VPWR VPWR _0921_ sky130_fd_sc_hd__or2_1
X_1607_ _0962_ _0973_ _0972_ VGND VGND VPWR VPWR _0978_ sky130_fd_sc_hd__a21oi_1
XFILLER_50_260 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_42_238 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_10_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_4_8_0_sys_clk clknet_0_sys_clk VGND VGND VPWR VPWR clknet_4_8_0_sys_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_5_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_6_128 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_12_64 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_12_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_5_161 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_37_83 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_37_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_28_296 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_53_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_11_196 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1323_ div_inst.counter\[24\] _0703_ _0701_ VGND VGND VPWR VPWR _0706_ sky130_fd_sc_hd__a21o_1
XFILLER_38_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_5_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1254_ _0612_ _0613_ _0625_ _0639_ VGND VGND VPWR VPWR _0641_ sky130_fd_sc_hd__a211o_1
X_1185_ _0578_ _0579_ VGND VGND VPWR VPWR _0580_ sky130_fd_sc_hd__and2_1
XFILLER_59_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_58_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_2_142 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_46_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_24_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1941_ _0374_ _0375_ VGND VGND VPWR VPWR _0376_ sky130_fd_sc_hd__nor2_1
X_1872_ _0315_ _0316_ VGND VGND VPWR VPWR _0317_ sky130_fd_sc_hd__nor2_1
X_1306_ div_inst.counter\[31\] _0688_ VGND VGND VPWR VPWR _0689_ sky130_fd_sc_hd__nor2_1
X_1237_ _0612_ _0613_ _0625_ VGND VGND VPWR VPWR _0626_ sky130_fd_sc_hd__a21oi_1
XFILLER_52_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_44_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1168_ dco_inst.accumulator\[18\] net76 VGND VGND VPWR VPWR _0565_ sky130_fd_sc_hd__or2_1
X_1099_ _0504_ _0505_ VGND VGND VPWR VPWR _0506_ sky130_fd_sc_hd__nand2_1
XFILLER_20_230 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_18_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_55_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_34_95 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_7_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_7_267 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2140_ clknet_4_8_0_sys_clk net284 net252 VGND VGND VPWR VPWR pfd_inst.ref_sync\[2\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_22_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_34_344 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2071_ clknet_4_4_0_sys_clk _0012_ VGND VGND VPWR VPWR dco_inst.accumulator\[8\]
+ sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_44_394 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1924_ _0359_ _0360_ VGND VGND VPWR VPWR _0361_ sky130_fd_sc_hd__nor2_1
X_1855_ lf_inst.integrator\[7\] net134 VGND VGND VPWR VPWR _0302_ sky130_fd_sc_hd__xnor2_2
X_1786_ net285 _0246_ net141 VGND VGND VPWR VPWR _0248_ sky130_fd_sc_hd__o21ai_1
XFILLER_29_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_29_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_52_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_40_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_25_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold40 net81 VGND VGND VPWR VPWR net315 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_20_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold62 lf_inst.integrator\[26\] VGND VGND VPWR VPWR net337 sky130_fd_sc_hd__dlygate4sd3_1
Xhold51 lf_inst.integrator\[27\] VGND VGND VPWR VPWR net326 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_29_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_28_171 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_16_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_41_375 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1571_ _0892_ _0895_ _0930_ _0953_ VGND VGND VPWR VPWR _0954_ sky130_fd_sc_hd__and4b_1
XFILLER_3_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_6_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1640_ net230 net39 VGND VGND VPWR VPWR _1007_ sky130_fd_sc_hd__and2_1
X_2123_ clknet_4_14_0_sys_clk _0061_ VGND VGND VPWR VPWR lf_inst.integrator\[24\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_26_108 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2054_ _0847_ net109 VGND VGND VPWR VPWR _0140_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_32_320 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_22_325 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1838_ _0286_ _0287_ VGND VGND VPWR VPWR _0288_ sky130_fd_sc_hd__nand2_1
X_1907_ net173 _0344_ _0345_ _0346_ VGND VGND VPWR VPWR _0096_ sky130_fd_sc_hd__a31o_1
X_1769_ lf_inst.integrator\[31\] _0235_ VGND VGND VPWR VPWR _0236_ sky130_fd_sc_hd__xnor2_1
XFILLER_25_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_40_155 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_25_174 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_13_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xoutput85 net85 VGND VGND VPWR VPWR debug_dco_word[26] sky130_fd_sc_hd__buf_2
Xoutput74 net74 VGND VGND VPWR VPWR debug_dco_word[16] sky130_fd_sc_hd__buf_2
XFILLER_0_295 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xoutput96 net96 VGND VGND VPWR VPWR debug_dco_word[7] sky130_fd_sc_hd__buf_2
XFILLER_48_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_16_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1554_ _0866_ _0882_ _0936_ VGND VGND VPWR VPWR _0937_ sky130_fd_sc_hd__and3_1
X_1485_ _0825_ _0867_ VGND VGND VPWR VPWR _0868_ sky130_fd_sc_hd__or2_1
X_1623_ _0990_ _0991_ VGND VGND VPWR VPWR _0992_ sky130_fd_sc_hd__xnor2_1
.ends
