* NGSPICE file created from pll_top.ext - technology: sky130A

* Black-box entry subcircuit for sky130_fd_sc_hd__fill_1 abstract view
.subckt sky130_fd_sc_hd__fill_1 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a221o_1 abstract view
.subckt sky130_fd_sc_hd__a221o_1 A1 A2 B1 B2 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfxtp_1 abstract view
.subckt sky130_fd_sc_hd__dfxtp_1 CLK D VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__tapvpwrvgnd_1 abstract view
.subckt sky130_fd_sc_hd__tapvpwrvgnd_1 VGND VPWR
.ends

* Black-box entry subcircuit for sky130_ef_sc_hd__decap_12 abstract view
.subckt sky130_ef_sc_hd__decap_12 VPWR VGND VPB VNB
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_8 abstract view
.subckt sky130_fd_sc_hd__decap_8 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_6 abstract view
.subckt sky130_fd_sc_hd__decap_6 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_3 abstract view
.subckt sky130_fd_sc_hd__decap_3 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and2_1 abstract view
.subckt sky130_fd_sc_hd__and2_1 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__mux2_1 abstract view
.subckt sky130_fd_sc_hd__mux2_1 A0 A1 S VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_1 abstract view
.subckt sky130_fd_sc_hd__clkbuf_1 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__fill_2 abstract view
.subckt sky130_fd_sc_hd__fill_2 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__xnor2_1 abstract view
.subckt sky130_fd_sc_hd__xnor2_1 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_1 abstract view
.subckt sky130_fd_sc_hd__buf_1 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or2_1 abstract view
.subckt sky130_fd_sc_hd__or2_1 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or4bb_1 abstract view
.subckt sky130_fd_sc_hd__or4bb_1 A B C_N D_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_4 abstract view
.subckt sky130_fd_sc_hd__decap_4 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand2b_1 abstract view
.subckt sky130_fd_sc_hd__nand2b_1 A_N B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand2_1 abstract view
.subckt sky130_fd_sc_hd__nand2_1 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21ai_1 abstract view
.subckt sky130_fd_sc_hd__o21ai_1 A1 A2 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o22ai_1 abstract view
.subckt sky130_fd_sc_hd__o22ai_1 A1 A2 B1 B2 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and2b_1 abstract view
.subckt sky130_fd_sc_hd__and2b_1 A_N B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and4bb_1 abstract view
.subckt sky130_fd_sc_hd__and4bb_1 A_N B_N C D VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor2_1 abstract view
.subckt sky130_fd_sc_hd__nor2_1 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand4_2 abstract view
.subckt sky130_fd_sc_hd__nand4_2 A B C D VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlygate4sd3_1 abstract view
.subckt sky130_fd_sc_hd__dlygate4sd3_1 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o211a_1 abstract view
.subckt sky130_fd_sc_hd__o211a_1 A1 A2 B1 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o221a_1 abstract view
.subckt sky130_fd_sc_hd__o221a_1 A1 A2 B1 B2 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a22o_1 abstract view
.subckt sky130_fd_sc_hd__a22o_1 A1 A2 B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_2 abstract view
.subckt sky130_fd_sc_hd__buf_2 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and3_1 abstract view
.subckt sky130_fd_sc_hd__and3_1 A B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21a_1 abstract view
.subckt sky130_fd_sc_hd__o21a_1 A1 A2 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21o_1 abstract view
.subckt sky130_fd_sc_hd__a21o_1 A1 A2 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlymetal6s2s_1 abstract view
.subckt sky130_fd_sc_hd__dlymetal6s2s_1 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__inv_2 abstract view
.subckt sky130_fd_sc_hd__inv_2 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_8 abstract view
.subckt sky130_fd_sc_hd__clkbuf_8 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a31o_1 abstract view
.subckt sky130_fd_sc_hd__a31o_1 A1 A2 A3 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21bo_1 abstract view
.subckt sky130_fd_sc_hd__a21bo_1 A1 A2 B1_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__xnor2_4 abstract view
.subckt sky130_fd_sc_hd__xnor2_4 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a31oi_1 abstract view
.subckt sky130_fd_sc_hd__a31oi_1 A1 A2 A3 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21oi_1 abstract view
.subckt sky130_fd_sc_hd__a21oi_1 A1 A2 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o22ai_2 abstract view
.subckt sky130_fd_sc_hd__o22ai_2 A1 A2 B1 B2 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and4_1 abstract view
.subckt sky130_fd_sc_hd__and4_1 A B C D VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a41o_1 abstract view
.subckt sky130_fd_sc_hd__a41o_1 A1 A2 A3 A4 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and3b_1 abstract view
.subckt sky130_fd_sc_hd__and3b_1 A_N B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor3b_1 abstract view
.subckt sky130_fd_sc_hd__nor3b_1 A B C_N VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o211a_4 abstract view
.subckt sky130_fd_sc_hd__o211a_4 A1 A2 B1 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21ba_1 abstract view
.subckt sky130_fd_sc_hd__o21ba_1 A1 A2 B1_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a211o_1 abstract view
.subckt sky130_fd_sc_hd__a211o_1 A1 A2 B1 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o31ai_1 abstract view
.subckt sky130_fd_sc_hd__o31ai_1 A1 A2 A3 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand4_1 abstract view
.subckt sky130_fd_sc_hd__nand4_1 A B C D VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__xnor2_2 abstract view
.subckt sky130_fd_sc_hd__xnor2_2 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o31a_1 abstract view
.subckt sky130_fd_sc_hd__o31a_1 A1 A2 A3 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and4b_1 abstract view
.subckt sky130_fd_sc_hd__and4b_1 A_N B C D VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__xor2_1 abstract view
.subckt sky130_fd_sc_hd__xor2_1 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o211ai_1 abstract view
.subckt sky130_fd_sc_hd__o211ai_1 A1 A2 B1 C1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or4_2 abstract view
.subckt sky130_fd_sc_hd__or4_2 A B C D VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkinv_2 abstract view
.subckt sky130_fd_sc_hd__clkinv_2 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a31o_4 abstract view
.subckt sky130_fd_sc_hd__a31o_4 A1 A2 A3 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor3_1 abstract view
.subckt sky130_fd_sc_hd__nor3_1 A B C VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__xor2_2 abstract view
.subckt sky130_fd_sc_hd__xor2_2 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand3_1 abstract view
.subckt sky130_fd_sc_hd__nand3_1 A B C VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21boi_4 abstract view
.subckt sky130_fd_sc_hd__a21boi_4 A1 A2 B1_N VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a2111o_1 abstract view
.subckt sky130_fd_sc_hd__a2111o_1 A1 A2 B1 C1 D1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a211oi_1 abstract view
.subckt sky130_fd_sc_hd__a211oi_1 A1 A2 B1 C1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand4b_1 abstract view
.subckt sky130_fd_sc_hd__nand4b_1 A_N B C D VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_2 abstract view
.subckt sky130_fd_sc_hd__clkbuf_2 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or4_4 abstract view
.subckt sky130_fd_sc_hd__or4_4 A B C D VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or4_1 abstract view
.subckt sky130_fd_sc_hd__or4_1 A B C D VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o2111a_1 abstract view
.subckt sky130_fd_sc_hd__o2111a_1 A1 A2 B1 C1 D1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or3b_1 abstract view
.subckt sky130_fd_sc_hd__or3b_1 A B C_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__bufinv_16 abstract view
.subckt sky130_fd_sc_hd__bufinv_16 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or4b_1 abstract view
.subckt sky130_fd_sc_hd__or4b_1 A B C D_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21boi_1 abstract view
.subckt sky130_fd_sc_hd__a21boi_1 A1 A2 B1_N VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand3_2 abstract view
.subckt sky130_fd_sc_hd__nand3_2 A B C VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkinvlp_4 abstract view
.subckt sky130_fd_sc_hd__clkinvlp_4 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or3_4 abstract view
.subckt sky130_fd_sc_hd__or3_4 A B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o22a_1 abstract view
.subckt sky130_fd_sc_hd__o22a_1 A1 A2 B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand2_2 abstract view
.subckt sky130_fd_sc_hd__nand2_2 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkinv_4 abstract view
.subckt sky130_fd_sc_hd__clkinv_4 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or2_2 abstract view
.subckt sky130_fd_sc_hd__or2_2 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a311o_1 abstract view
.subckt sky130_fd_sc_hd__a311o_1 A1 A2 A3 B1 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_6 abstract view
.subckt sky130_fd_sc_hd__buf_6 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or3_1 abstract view
.subckt sky130_fd_sc_hd__or3_1 A B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o2bb2a_1 abstract view
.subckt sky130_fd_sc_hd__o2bb2a_1 A1_N A2_N B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o41a_1 abstract view
.subckt sky130_fd_sc_hd__o41a_1 A1 A2 A3 A4 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o32a_1 abstract view
.subckt sky130_fd_sc_hd__o32a_1 A1 A2 A3 B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a2111oi_1 abstract view
.subckt sky130_fd_sc_hd__a2111oi_1 A1 A2 B1 C1 D1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o211ai_4 abstract view
.subckt sky130_fd_sc_hd__o211ai_4 A1 A2 B1 C1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o311a_1 abstract view
.subckt sky130_fd_sc_hd__o311a_1 A1 A2 A3 B1 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a22oi_1 abstract view
.subckt sky130_fd_sc_hd__a22oi_1 A1 A2 B1 B2 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21bai_1 abstract view
.subckt sky130_fd_sc_hd__o21bai_1 A1 A2 B1_N VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or2_4 abstract view
.subckt sky130_fd_sc_hd__or2_4 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21boi_2 abstract view
.subckt sky130_fd_sc_hd__a21boi_2 A1 A2 B1_N VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a2111oi_2 abstract view
.subckt sky130_fd_sc_hd__a2111oi_2 A1 A2 B1 C1 D1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a22oi_2 abstract view
.subckt sky130_fd_sc_hd__a22oi_2 A1 A2 B1 B2 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfxtp_2 abstract view
.subckt sky130_fd_sc_hd__dfxtp_2 CLK D VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__mux2_4 abstract view
.subckt sky130_fd_sc_hd__mux2_4 A0 A1 S VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o221a_4 abstract view
.subckt sky130_fd_sc_hd__o221a_4 A1 A2 B1 B2 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor2_2 abstract view
.subckt sky130_fd_sc_hd__nor2_2 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a32o_1 abstract view
.subckt sky130_fd_sc_hd__a32o_1 A1 A2 A3 B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand3b_1 abstract view
.subckt sky130_fd_sc_hd__nand3b_1 A_N B C VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlygate4sd1_1 abstract view
.subckt sky130_fd_sc_hd__dlygate4sd1_1 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o31ai_4 abstract view
.subckt sky130_fd_sc_hd__o31ai_4 A1 A2 A3 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_16 abstract view
.subckt sky130_fd_sc_hd__clkbuf_16 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a31oi_4 abstract view
.subckt sky130_fd_sc_hd__a31oi_4 A1 A2 A3 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a211oi_2 abstract view
.subckt sky130_fd_sc_hd__a211oi_2 A1 A2 B1 C1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a2bb2o_1 abstract view
.subckt sky130_fd_sc_hd__a2bb2o_1 A1_N A2_N B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__diode_2 abstract view
.subckt sky130_fd_sc_hd__diode_2 DIODE VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or3b_2 abstract view
.subckt sky130_fd_sc_hd__or3b_2 A B C_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a211o_4 abstract view
.subckt sky130_fd_sc_hd__a211o_4 A1 A2 B1 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor4_1 abstract view
.subckt sky130_fd_sc_hd__nor4_1 A B C D VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and2_4 abstract view
.subckt sky130_fd_sc_hd__and2_4 A B VGND VNB VPB VPWR X
.ends

.subckt pll_top VGND VPWR debug_dco_word[0] debug_dco_word[10] debug_dco_word[11]
+ debug_dco_word[12] debug_dco_word[13] debug_dco_word[14] debug_dco_word[15] debug_dco_word[16]
+ debug_dco_word[17] debug_dco_word[18] debug_dco_word[19] debug_dco_word[1] debug_dco_word[20]
+ debug_dco_word[21] debug_dco_word[22] debug_dco_word[23] debug_dco_word[24] debug_dco_word[25]
+ debug_dco_word[26] debug_dco_word[27] debug_dco_word[28] debug_dco_word[29] debug_dco_word[2]
+ debug_dco_word[30] debug_dco_word[31] debug_dco_word[3] debug_dco_word[4] debug_dco_word[5]
+ debug_dco_word[6] debug_dco_word[7] debug_dco_word[8] debug_dco_word[9] div_val[0]
+ div_val[10] div_val[11] div_val[12] div_val[13] div_val[14] div_val[15] div_val[16]
+ div_val[17] div_val[18] div_val[19] div_val[1] div_val[20] div_val[21] div_val[22]
+ div_val[23] div_val[24] div_val[25] div_val[26] div_val[27] div_val[28] div_val[29]
+ div_val[2] div_val[30] div_val[31] div_val[3] div_val[4] div_val[5] div_val[6] div_val[7]
+ div_val[8] div_val[9] initial_freq[0] initial_freq[10] initial_freq[11] initial_freq[12]
+ initial_freq[13] initial_freq[14] initial_freq[15] initial_freq[16] initial_freq[17]
+ initial_freq[18] initial_freq[19] initial_freq[1] initial_freq[20] initial_freq[21]
+ initial_freq[22] initial_freq[23] initial_freq[24] initial_freq[25] initial_freq[26]
+ initial_freq[27] initial_freq[28] initial_freq[29] initial_freq[2] initial_freq[30]
+ initial_freq[31] initial_freq[3] initial_freq[4] initial_freq[5] initial_freq[6]
+ initial_freq[7] initial_freq[8] initial_freq[9] lock_detect pll_out ref_clk rst_n
+ sys_clk
XFILLER_54_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2037_ net371 net187 _0461_ _0462_ _0255_ VGND VGND VPWR VPWR _0115_ sky130_fd_sc_hd__a221o_1
X_2106_ clknet_4_1_0_sys_clk _0009_ VGND VGND VPWR VPWR dco_inst.accumulator\[5\]
+ sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_60_492 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_52_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_10_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_10_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_45_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_26_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_13_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_42_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_9_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_8_181 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1270_ _0662_ _0674_ VGND VGND VPWR VPWR _0675_ sky130_fd_sc_hd__and2_1
XFILLER_3_89 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1606_ net63 net323 net286 VGND VGND VPWR VPWR _0044_ sky130_fd_sc_hd__mux2_1
XFILLER_59_317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout149 div_inst.counter\[1\] VGND VGND VPWR VPWR net149 sky130_fd_sc_hd__clkbuf_1
XFILLER_47_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1537_ div_inst.counter\[9\] _0851_ VGND VGND VPWR VPWR _0938_ sky130_fd_sc_hd__xnor2_1
Xfanout105 net106 VGND VGND VPWR VPWR net105 sky130_fd_sc_hd__buf_1
Xfanout116 net117 VGND VGND VPWR VPWR net116 sky130_fd_sc_hd__clkbuf_1
Xfanout138 _0859_ VGND VGND VPWR VPWR net138 sky130_fd_sc_hd__buf_1
X_1468_ div_inst.counter\[30\] _0868_ VGND VGND VPWR VPWR _0869_ sky130_fd_sc_hd__or2_1
X_1399_ _0788_ _0790_ _0791_ _0795_ VGND VGND VPWR VPWR _0800_ sky130_fd_sc_hd__or4bb_1
XFILLER_35_291 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_27_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_50_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_12_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_2_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_58_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_37_40 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_5_162 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_18_258 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_28_297 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_11_197 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1253_ _0658_ _0659_ VGND VGND VPWR VPWR _0660_ sky130_fd_sc_hd__nand2b_1
XFILLER_56_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1322_ net30 _0696_ VGND VGND VPWR VPWR _0723_ sky130_fd_sc_hd__and2_1
X_1184_ dco_inst.accumulator\[17\] net75 VGND VGND VPWR VPWR _0600_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_19_242 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_59_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_47_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_2_143 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_25_278 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_15_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_23_31 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_38_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_58_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1871_ _0313_ _0319_ _0318_ VGND VGND VPWR VPWR _0320_ sky130_fd_sc_hd__o21ai_1
X_1940_ _0375_ _0377_ VGND VGND VPWR VPWR _0379_ sky130_fd_sc_hd__xnor2_1
X_1236_ dco_inst.accumulator\[24\] net83 VGND VGND VPWR VPWR _0645_ sky130_fd_sc_hd__nand2_1
XFILLER_56_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1305_ div_inst.counter\[15\] _0704_ _0705_ div_inst.counter\[14\] VGND VGND VPWR
+ VPWR _0706_ sky130_fd_sc_hd__o22ai_1
X_1098_ dco_inst.accumulator\[5\] net94 VGND VGND VPWR VPWR _0526_ sky130_fd_sc_hd__nand2_1
XFILLER_12_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1167_ _0585_ _0584_ VGND VGND VPWR VPWR _0018_ sky130_fd_sc_hd__and2b_1
XFILLER_60_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_8_Left_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_18_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_34_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_34_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_7_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2070_ net275 _0951_ net109 net121 VGND VGND VPWR VPWR _0124_ sky130_fd_sc_hd__and4bb_1
XFILLER_38_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_34_323 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1785_ net198 _0249_ VGND VGND VPWR VPWR _0250_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_44_395 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1854_ lf_inst.integrator\[2\] net164 VGND VGND VPWR VPWR _0305_ sky130_fd_sc_hd__nand2_1
X_1923_ _0342_ _0348_ _0353_ _0359_ VGND VGND VPWR VPWR _0364_ sky130_fd_sc_hd__nand4_2
X_1219_ dco_inst.accumulator\[22\] net81 VGND VGND VPWR VPWR _0630_ sky130_fd_sc_hd__or2_1
XFILLER_25_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2199_ clknet_4_4_0_sys_clk _0098_ VGND VGND VPWR VPWR net68 sky130_fd_sc_hd__dfxtp_1
XFILLER_52_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_35_340 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold30 net84 VGND VGND VPWR VPWR net340 sky130_fd_sc_hd__dlygate4sd3_1
Xhold41 net81 VGND VGND VPWR VPWR net351 sky130_fd_sc_hd__dlygate4sd3_1
Xhold52 net88 VGND VGND VPWR VPWR net362 sky130_fd_sc_hd__dlygate4sd3_1
Xhold63 lf_inst.integrator\[21\] VGND VGND VPWR VPWR net373 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_58_476 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_43_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_16_323 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_41_376 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_31_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1570_ net151 net311 _0967_ _0970_ VGND VGND VPWR VPWR _0971_ sky130_fd_sc_hd__o211a_1
XFILLER_3_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2053_ net362 net186 _0475_ _0476_ _0272_ VGND VGND VPWR VPWR _0117_ sky130_fd_sc_hd__a221o_1
X_2122_ clknet_4_10_0_sys_clk _0025_ VGND VGND VPWR VPWR dco_inst.accumulator\[21\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_19_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_34_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_32_321 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1768_ net297 net49 _1018_ net357 _0234_ VGND VGND VPWR VPWR _0074_ sky130_fd_sc_hd__o221a_1
X_1837_ lf_inst.zero_error_count\[1\] _0289_ net133 _0292_ VGND VGND VPWR VPWR _0293_
+ sky130_fd_sc_hd__a22o_1
X_1906_ _0345_ _0348_ VGND VGND VPWR VPWR _0350_ sky130_fd_sc_hd__xnor2_1
XFILLER_57_234 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_57_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1699_ net178 _0173_ VGND VGND VPWR VPWR _0174_ sky130_fd_sc_hd__or2_1
XFILLER_57_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_25_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_13_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput75 net75 VGND VGND VPWR VPWR debug_dco_word[17] sky130_fd_sc_hd__buf_2
Xoutput86 net86 VGND VGND VPWR VPWR debug_dco_word[27] sky130_fd_sc_hd__buf_2
XFILLER_56_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_56_50 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput97 net97 VGND VGND VPWR VPWR debug_dco_word[8] sky130_fd_sc_hd__buf_2
XFILLER_16_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_16_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_16_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1622_ net209 _1005_ _1006_ VGND VGND VPWR VPWR _0053_ sky130_fd_sc_hd__and3_1
X_1553_ _0849_ _0953_ VGND VGND VPWR VPWR _0954_ sky130_fd_sc_hd__or2_1
XFILLER_39_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1484_ div_inst.counter\[24\] _0864_ VGND VGND VPWR VPWR _0885_ sky130_fd_sc_hd__xnor2_1
Xfanout309 net18 VGND VGND VPWR VPWR net309 sky130_fd_sc_hd__buf_1
X_2036_ _0458_ _0460_ net204 VGND VGND VPWR VPWR _0462_ sky130_fd_sc_hd__o21a_1
XFILLER_39_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_39_267 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2105_ clknet_4_1_0_sys_clk _0008_ VGND VGND VPWR VPWR dco_inst.accumulator\[4\]
+ sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_60_493 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_10_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_22_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_37_Left_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_13_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_39_Left_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_47_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_3_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1536_ _0934_ _0936_ VGND VGND VPWR VPWR _0937_ sky130_fd_sc_hd__nand2_1
X_1605_ net286 net335 _0998_ VGND VGND VPWR VPWR _0043_ sky130_fd_sc_hd__a21o_1
XFILLER_59_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xfanout106 net112 VGND VGND VPWR VPWR net106 sky130_fd_sc_hd__buf_1
Xfanout117 net118 VGND VGND VPWR VPWR net117 sky130_fd_sc_hd__buf_1
XFILLER_27_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout139 div_inst.counter\[21\] VGND VGND VPWR VPWR net139 sky130_fd_sc_hd__dlymetal6s2s_1
X_1398_ _0798_ VGND VGND VPWR VPWR _0799_ sky130_fd_sc_hd__inv_2
X_1467_ div_inst.counter\[29\] _0867_ VGND VGND VPWR VPWR _0868_ sky130_fd_sc_hd__and2_1
X_2019_ _0241_ net157 VGND VGND VPWR VPWR _0447_ sky130_fd_sc_hd__nor2_1
XFILLER_50_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_6_108 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_37_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_5_163 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_28_298 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_26_292 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_5_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_11_198 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1252_ dco_inst.accumulator\[26\] net85 VGND VGND VPWR VPWR _0659_ sky130_fd_sc_hd__nand2_1
X_1321_ div_inst.counter\[9\] _0720_ _0721_ div_inst.counter\[8\] VGND VGND VPWR VPWR
+ _0722_ sky130_fd_sc_hd__o22ai_1
X_1183_ dco_inst.accumulator\[17\] net75 VGND VGND VPWR VPWR _0599_ sky130_fd_sc_hd__or2_1
XTAP_TAPCELL_ROW_19_243 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_4_10_0_sys_clk clknet_0_sys_clk VGND VGND VPWR VPWR clknet_4_10_0_sys_clk
+ sky130_fd_sc_hd__clkbuf_8
X_1519_ net131 _0919_ VGND VGND VPWR VPWR _0920_ sky130_fd_sc_hd__nand2b_1
XPHY_EDGE_ROW_12_Right_12 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_59_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_2_144 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_21_Right_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_25_279 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_30_Right_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_23_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_2_155 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_16_224 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1870_ _0496_ net136 _0306_ _0307_ _0305_ VGND VGND VPWR VPWR _0319_ sky130_fd_sc_hd__o221a_1
XFILLER_43_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_24_Left_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1235_ dco_inst.accumulator\[24\] net83 VGND VGND VPWR VPWR _0644_ sky130_fd_sc_hd__or2_1
XFILLER_49_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1304_ net6 _0701_ VGND VGND VPWR VPWR _0705_ sky130_fd_sc_hd__xnor2_1
X_1166_ _0579_ _0582_ _0583_ net252 VGND VGND VPWR VPWR _0585_ sky130_fd_sc_hd__a31o_1
X_1097_ dco_inst.accumulator\[5\] net94 VGND VGND VPWR VPWR _0525_ sky130_fd_sc_hd__or2_1
XFILLER_20_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1999_ _0420_ _0422_ _0421_ VGND VGND VPWR VPWR _0430_ sky130_fd_sc_hd__a21bo_1
XTAP_TAPCELL_ROW_38_360 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_50_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_7_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_50_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_19_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_44_396 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_34_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1922_ _1039_ net137 VGND VGND VPWR VPWR _0363_ sky130_fd_sc_hd__xnor2_1
X_1784_ _0248_ _0247_ VGND VGND VPWR VPWR _0249_ sky130_fd_sc_hd__xnor2_4
X_1853_ net231 net166 VGND VGND VPWR VPWR _0304_ sky130_fd_sc_hd__or2_1
X_1218_ _0628_ _0629_ VGND VGND VPWR VPWR _0025_ sky130_fd_sc_hd__nor2_1
X_2198_ clknet_4_4_0_sys_clk _0097_ VGND VGND VPWR VPWR net98 sky130_fd_sc_hd__dfxtp_1
X_1149_ _0568_ _0569_ VGND VGND VPWR VPWR _0570_ sky130_fd_sc_hd__and2_1
XFILLER_52_154 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_35_341 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold53 lf_inst.zero_error_count\[0\] VGND VGND VPWR VPWR net363 sky130_fd_sc_hd__dlygate4sd3_1
Xhold31 pfd_inst.fb_sync\[1\] VGND VGND VPWR VPWR net341 sky130_fd_sc_hd__dlygate4sd3_1
Xhold64 lf_inst.integrator\[5\] VGND VGND VPWR VPWR net374 sky130_fd_sc_hd__dlygate4sd3_1
Xhold20 net95 VGND VGND VPWR VPWR net330 sky130_fd_sc_hd__dlygate4sd3_1
Xhold42 net96 VGND VGND VPWR VPWR net352 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_58_477 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_43_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_31_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_16_335 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_41_377 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_3_261 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2052_ _0466_ _0470_ _0474_ net198 VGND VGND VPWR VPWR _0476_ sky130_fd_sc_hd__a31oi_1
XTAP_TAPCELL_ROW_49_422 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2121_ clknet_4_10_0_sys_clk _0024_ VGND VGND VPWR VPWR dco_inst.accumulator\[20\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_19_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_34_176 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_32_322 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1905_ _0345_ _0347_ VGND VGND VPWR VPWR _0349_ sky130_fd_sc_hd__nor2_1
X_1767_ net203 _0233_ VGND VGND VPWR VPWR _0234_ sky130_fd_sc_hd__nand2_1
X_1836_ lf_inst.zero_error_count\[1\] lf_inst.zero_error_count\[0\] VGND VGND VPWR
+ VPWR _0292_ sky130_fd_sc_hd__nand2_1
X_1698_ net263 net40 VGND VGND VPWR VPWR _0173_ sky130_fd_sc_hd__and2_1
XPHY_EDGE_ROW_6_Right_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_57_246 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_55_458 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_11_Left_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_13_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_15_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_31_32 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xoutput87 net87 VGND VGND VPWR VPWR debug_dco_word[28] sky130_fd_sc_hd__buf_2
Xoutput76 net76 VGND VGND VPWR VPWR debug_dco_word[18] sky130_fd_sc_hd__buf_2
XFILLER_0_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput98 net98 VGND VGND VPWR VPWR debug_dco_word[9] sky130_fd_sc_hd__buf_2
XFILLER_0_231 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_56_62 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_48_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_59_Right_59 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1552_ net146 _0848_ div_inst.counter\[5\] VGND VGND VPWR VPWR _0953_ sky130_fd_sc_hd__a21oi_1
X_1621_ unlock_timer\[3\] _1004_ VGND VGND VPWR VPWR _1006_ sky130_fd_sc_hd__nand2_1
X_2104_ clknet_4_0_0_sys_clk _0007_ VGND VGND VPWR VPWR dco_inst.accumulator\[3\]
+ sky130_fd_sc_hd__dfxtp_1
X_1483_ _0865_ _0883_ VGND VGND VPWR VPWR _0884_ sky130_fd_sc_hd__or2_1
X_2035_ _0458_ _0460_ VGND VGND VPWR VPWR _0461_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_60_494 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1819_ _0273_ _0276_ _0274_ VGND VGND VPWR VPWR _0279_ sky130_fd_sc_hd__o21a_1
XFILLER_26_10 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_36_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_36_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1535_ net3 _0935_ VGND VGND VPWR VPWR _0936_ sky130_fd_sc_hd__nand2_1
Xfanout107 net108 VGND VGND VPWR VPWR net107 sky130_fd_sc_hd__buf_1
Xfanout118 net124 VGND VGND VPWR VPWR net118 sky130_fd_sc_hd__buf_1
X_1604_ net255 net62 VGND VGND VPWR VPWR _0998_ sky130_fd_sc_hd__and2_1
Xfanout129 _0766_ VGND VGND VPWR VPWR net129 sky130_fd_sc_hd__buf_1
XFILLER_27_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1397_ div_inst.counter\[25\] _0793_ _0797_ div_inst.counter\[24\] VGND VGND VPWR
+ VPWR _0798_ sky130_fd_sc_hd__o22ai_2
X_1466_ div_inst.counter\[28\] div_inst.counter\[27\] _0866_ VGND VGND VPWR VPWR _0867_
+ sky130_fd_sc_hd__and3_1
XFILLER_50_230 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2018_ _0439_ _0442_ VGND VGND VPWR VPWR _0446_ sky130_fd_sc_hd__nor2_1
XFILLER_10_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_33_208 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_28_299 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_26_260 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_53_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_41_252 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_41_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1320_ net303 _0697_ VGND VGND VPWR VPWR _0721_ sky130_fd_sc_hd__xnor2_1
XTAP_TAPCELL_ROW_11_199 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1251_ dco_inst.accumulator\[26\] net85 VGND VGND VPWR VPWR _0658_ sky130_fd_sc_hd__nor2_1
X_1182_ net285 _0597_ _0598_ VGND VGND VPWR VPWR _0020_ sky130_fd_sc_hd__and3_1
XTAP_TAPCELL_ROW_19_244 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_59_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_58_Left_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1449_ div_inst.counter\[6\] div_inst.counter\[5\] net146 _0848_ VGND VGND VPWR VPWR
+ _0850_ sky130_fd_sc_hd__and4_1
Xclkbuf_4_14_0_sys_clk clknet_0_sys_clk VGND VGND VPWR VPWR clknet_4_14_0_sys_clk
+ sky130_fd_sc_hd__clkbuf_8
X_1518_ div_inst.counter\[14\] net141 net142 net132 div_inst.counter\[15\] VGND VGND
+ VPWR VPWR _0919_ sky130_fd_sc_hd__a41o_1
XTAP_TAPCELL_ROW_2_145 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_3_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_58_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_46_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_14_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_16_225 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_14_285 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1303_ _0702_ _0703_ VGND VGND VPWR VPWR _0704_ sky130_fd_sc_hd__and2_1
X_1234_ net294 _0642_ _0643_ VGND VGND VPWR VPWR _0027_ sky130_fd_sc_hd__and3_1
XFILLER_37_344 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1096_ _0524_ net282 _0523_ VGND VGND VPWR VPWR _0008_ sky130_fd_sc_hd__and3b_1
X_1165_ _0582_ _0583_ _0579_ VGND VGND VPWR VPWR _0584_ sky130_fd_sc_hd__a21o_1
X_1998_ _0427_ _0428_ VGND VGND VPWR VPWR _0429_ sky130_fd_sc_hd__nand2b_1
XTAP_TAPCELL_ROW_38_361 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_13_206 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_50_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_7_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_11_200 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_11_288 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_50_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_46_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_46_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xfanout290 net291 VGND VGND VPWR VPWR net290 sky130_fd_sc_hd__clkbuf_1
XFILLER_22_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_44_397 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1852_ net247 net231 net211 VGND VGND VPWR VPWR _0303_ sky130_fd_sc_hd__nor3b_1
X_1921_ net200 _0360_ _0361_ _0362_ VGND VGND VPWR VPWR _0099_ sky130_fd_sc_hd__a31o_1
X_1783_ _0238_ _0231_ _0236_ _0225_ VGND VGND VPWR VPWR _0248_ sky130_fd_sc_hd__o211a_4
XFILLER_29_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_52_166 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1217_ _0618_ _0624_ _0627_ net267 VGND VGND VPWR VPWR _0629_ sky130_fd_sc_hd__a31o_1
XFILLER_37_185 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_35_342 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_25_347 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1079_ dco_inst.accumulator\[2\] net89 VGND VGND VPWR VPWR _0510_ sky130_fd_sc_hd__or2_1
X_2197_ clknet_4_5_0_sys_clk _0096_ VGND VGND VPWR VPWR net97 sky130_fd_sc_hd__dfxtp_1
X_1148_ dco_inst.accumulator\[12\] net70 VGND VGND VPWR VPWR _0569_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_58_478 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold32 lf_inst.integrator\[23\] VGND VGND VPWR VPWR net342 sky130_fd_sc_hd__dlygate4sd3_1
Xhold21 net80 VGND VGND VPWR VPWR net331 sky130_fd_sc_hd__dlygate4sd3_1
Xhold43 net79 VGND VGND VPWR VPWR net353 sky130_fd_sc_hd__dlygate4sd3_1
Xhold10 lf_inst.integrator\[28\] VGND VGND VPWR VPWR net320 sky130_fd_sc_hd__dlygate4sd3_1
Xhold54 _0085_ VGND VGND VPWR VPWR net364 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_29_32 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_16_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold65 net70 VGND VGND VPWR VPWR net375 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_16_347 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_41_378 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_49_423 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2120_ clknet_4_8_0_sys_clk _0023_ VGND VGND VPWR VPWR dco_inst.accumulator\[19\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_3_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2051_ _0466_ _0470_ _0474_ VGND VGND VPWR VPWR _0475_ sky130_fd_sc_hd__a21o_1
XFILLER_19_152 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1835_ net297 _0291_ VGND VGND VPWR VPWR _0084_ sky130_fd_sc_hd__and2_1
XFILLER_34_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_32_323 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1904_ _0346_ _0347_ VGND VGND VPWR VPWR _0348_ sky130_fd_sc_hd__nor2_1
X_1766_ _0231_ _0232_ VGND VGND VPWR VPWR _0233_ sky130_fd_sc_hd__nand2_1
X_1697_ net193 _0171_ VGND VGND VPWR VPWR _0172_ sky130_fd_sc_hd__nor2_1
XFILLER_57_258 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_57_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_57_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2249_ net237 _0148_ VGND VGND VPWR VPWR div_inst.counter\[28\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_55_459 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_25_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_25_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xoutput88 net88 VGND VGND VPWR VPWR debug_dco_word[29] sky130_fd_sc_hd__buf_2
Xoutput77 net77 VGND VGND VPWR VPWR debug_dco_word[19] sky130_fd_sc_hd__buf_2
XFILLER_0_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_210 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xoutput99 net99 VGND VGND VPWR VPWR lock_detect sky130_fd_sc_hd__buf_2
XFILLER_56_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_56_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_46_404 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_16_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1551_ net28 _0951_ VGND VGND VPWR VPWR _0952_ sky130_fd_sc_hd__or2_1
X_1482_ div_inst.counter\[24\] _0864_ div_inst.counter\[25\] VGND VGND VPWR VPWR _0883_
+ sky130_fd_sc_hd__a21oi_1
X_1620_ unlock_timer\[3\] _1004_ VGND VGND VPWR VPWR _1005_ sky130_fd_sc_hd__or2_1
XFILLER_39_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_39_203 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2103_ clknet_4_0_0_sys_clk _0006_ VGND VGND VPWR VPWR dco_inst.accumulator\[2\]
+ sky130_fd_sc_hd__dfxtp_1
X_2034_ _0449_ _0453_ _0455_ _0452_ VGND VGND VPWR VPWR _0460_ sky130_fd_sc_hd__a31o_1
XTAP_TAPCELL_ROW_60_495 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1818_ net324 net185 _0277_ net205 _0278_ VGND VGND VPWR VPWR _0080_ sky130_fd_sc_hd__a221o_1
XFILLER_10_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1749_ net267 net47 VGND VGND VPWR VPWR _0218_ sky130_fd_sc_hd__and2_1
XFILLER_21_180 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_36_217 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_44_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_12_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1534_ div_inst.counter\[10\] _0853_ VGND VGND VPWR VPWR _0935_ sky130_fd_sc_hd__xnor2_1
Xfanout108 net111 VGND VGND VPWR VPWR net108 sky130_fd_sc_hd__buf_1
Xfanout119 net120 VGND VGND VPWR VPWR net119 sky130_fd_sc_hd__buf_1
X_1603_ net61 net367 net286 VGND VGND VPWR VPWR _0042_ sky130_fd_sc_hd__mux2_1
X_1465_ div_inst.counter\[26\] _0865_ VGND VGND VPWR VPWR _0866_ sky130_fd_sc_hd__and2_1
X_2017_ net334 _1018_ _0445_ VGND VGND VPWR VPWR _0112_ sky130_fd_sc_hd__o21ba_1
XFILLER_42_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1396_ _0768_ _0796_ VGND VGND VPWR VPWR _0797_ sky130_fd_sc_hd__and2_1
XFILLER_50_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_10_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_37_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_26_272 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_38_7 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1250_ _0656_ _0657_ VGND VGND VPWR VPWR _0029_ sky130_fd_sc_hd__nor2_1
XFILLER_49_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1181_ _0592_ _0596_ VGND VGND VPWR VPWR _0598_ sky130_fd_sc_hd__or2_1
XTAP_TAPCELL_ROW_19_245 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_17_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_17_294 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1448_ div_inst.counter\[5\] net146 _0848_ VGND VGND VPWR VPWR _0849_ sky130_fd_sc_hd__and3_1
X_1517_ _0906_ _0909_ _0916_ _0905_ VGND VGND VPWR VPWR _0918_ sky130_fd_sc_hd__a31oi_1
X_1379_ div_inst.counter\[28\] _0779_ VGND VGND VPWR VPWR _0780_ sky130_fd_sc_hd__and2_1
XFILLER_23_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_14_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_14_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_16_226 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_56_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1233_ _0631_ _0638_ _0639_ _0640_ VGND VGND VPWR VPWR _0643_ sky130_fd_sc_hd__a211o_1
X_1302_ net302 net6 _0700_ net7 VGND VGND VPWR VPWR _0703_ sky130_fd_sc_hd__o31ai_1
XFILLER_52_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1095_ _0519_ _0521_ _0522_ VGND VGND VPWR VPWR _0524_ sky130_fd_sc_hd__and3_1
X_1164_ _0569_ _0573_ _0572_ VGND VGND VPWR VPWR _0583_ sky130_fd_sc_hd__a21o_1
X_1997_ _0216_ net153 VGND VGND VPWR VPWR _0428_ sky130_fd_sc_hd__nand2_1
XFILLER_20_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_55_142 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_13_207 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_50_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_7_249 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xwire125 net126 VGND VGND VPWR VPWR net125 sky130_fd_sc_hd__clkbuf_1
XFILLER_59_30 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_34_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout291 net292 VGND VGND VPWR VPWR net291 sky130_fd_sc_hd__clkbuf_1
Xfanout280 net8 VGND VGND VPWR VPWR net280 sky130_fd_sc_hd__buf_1
X_1851_ net365 _0302_ _1018_ VGND VGND VPWR VPWR _0089_ sky130_fd_sc_hd__mux2_1
X_1920_ net69 net174 _1034_ VGND VGND VPWR VPWR _0362_ sky130_fd_sc_hd__a21o_1
X_1782_ _0246_ VGND VGND VPWR VPWR _0247_ sky130_fd_sc_hd__inv_2
X_1216_ _0618_ _0624_ _0627_ VGND VGND VPWR VPWR _0628_ sky130_fd_sc_hd__a21oi_1
X_2196_ clknet_4_5_0_sys_clk _0095_ VGND VGND VPWR VPWR net96 sky130_fd_sc_hd__dfxtp_1
XFILLER_52_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_40_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_37_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_37_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_35_343 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1078_ dco_inst.accumulator\[2\] net89 VGND VGND VPWR VPWR _0509_ sky130_fd_sc_hd__nand2_1
XFILLER_1_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1147_ dco_inst.accumulator\[12\] net70 VGND VGND VPWR VPWR _0568_ sky130_fd_sc_hd__or2_1
Xhold11 lf_inst.integrator\[29\] VGND VGND VPWR VPWR net321 sky130_fd_sc_hd__dlygate4sd3_1
Xhold22 net75 VGND VGND VPWR VPWR net332 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_29_44 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_20_68 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_58_479 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_45_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_28_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_28_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_28_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xhold33 net92 VGND VGND VPWR VPWR net343 sky130_fd_sc_hd__dlygate4sd3_1
Xhold55 net78 VGND VGND VPWR VPWR net365 sky130_fd_sc_hd__dlygate4sd3_1
Xhold44 net72 VGND VGND VPWR VPWR net354 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_41_379 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_6_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_49_424 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2050_ _0271_ _0472_ VGND VGND VPWR VPWR _0474_ sky130_fd_sc_hd__xnor2_1
XFILLER_13_6 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_20_7 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1765_ _0201_ _0226_ _0229_ _0230_ VGND VGND VPWR VPWR _0232_ sky130_fd_sc_hd__nand4_1
X_1834_ net133 _0289_ lf_inst.zero_error_count\[0\] VGND VGND VPWR VPWR _0291_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_32_324 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1903_ _1013_ net136 VGND VGND VPWR VPWR _0347_ sky130_fd_sc_hd__and2_1
X_1696_ _0168_ _0170_ VGND VGND VPWR VPWR _0171_ sky130_fd_sc_hd__xnor2_2
X_2179_ clknet_4_13_0_sys_clk _0079_ VGND VGND VPWR VPWR lf_inst.integrator\[29\]
+ sky130_fd_sc_hd__dfxtp_1
X_2248_ net237 _0147_ VGND VGND VPWR VPWR div_inst.counter\[27\] sky130_fd_sc_hd__dfxtp_1
XFILLER_25_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_15_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_31_67 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_31_12 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_48_259 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput67 net67 VGND VGND VPWR VPWR debug_dco_word[0] sky130_fd_sc_hd__buf_2
XFILLER_0_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xoutput89 net89 VGND VGND VPWR VPWR debug_dco_word[2] sky130_fd_sc_hd__buf_2
Xoutput78 net78 VGND VGND VPWR VPWR debug_dco_word[1] sky130_fd_sc_hd__buf_2
XFILLER_56_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_46_405 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_16_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_12_351 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1550_ net146 _0848_ VGND VGND VPWR VPWR _0951_ sky130_fd_sc_hd__xnor2_1
X_1481_ net20 _0880_ _0881_ net307 VGND VGND VPWR VPWR _0882_ sky130_fd_sc_hd__a22o_1
XFILLER_47_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2033_ _0254_ net160 VGND VGND VPWR VPWR _0459_ sky130_fd_sc_hd__xnor2_1
XFILLER_39_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_39_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_11_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2102_ clknet_4_0_0_sys_clk _0005_ VGND VGND VPWR VPWR dco_inst.accumulator\[1\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_22_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_22_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_60_496 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1817_ net272 net56 VGND VGND VPWR VPWR _0278_ sky130_fd_sc_hd__and2_1
X_1748_ _0216_ VGND VGND VPWR VPWR _0217_ sky130_fd_sc_hd__inv_2
X_1679_ _0154_ _0155_ VGND VGND VPWR VPWR _0156_ sky130_fd_sc_hd__and2_1
XFILLER_13_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_21_192 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_36_229 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_44_240 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1602_ net60 net374 net286 VGND VGND VPWR VPWR _0041_ sky130_fd_sc_hd__mux2_1
XFILLER_8_174 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout109 net111 VGND VGND VPWR VPWR net109 sky130_fd_sc_hd__clkbuf_1
X_1533_ net4 _0933_ VGND VGND VPWR VPWR _0934_ sky130_fd_sc_hd__nand2_1
X_1464_ div_inst.counter\[25\] div_inst.counter\[24\] _0864_ VGND VGND VPWR VPWR _0865_
+ sky130_fd_sc_hd__and3_1
X_1395_ net16 net310 net129 net17 VGND VGND VPWR VPWR _0796_ sky130_fd_sc_hd__o31ai_1
X_2016_ net266 _0442_ _0443_ _0444_ VGND VGND VPWR VPWR _0445_ sky130_fd_sc_hd__o31a_1
XFILLER_58_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_37_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_53_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_53_10 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_37_77 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_26_284 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_26_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_5_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_1_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1180_ _0592_ _0596_ VGND VGND VPWR VPWR _0597_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_19_246 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_32_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_27_290 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1516_ _0905_ _0906_ _0909_ _0910_ VGND VGND VPWR VPWR _0917_ sky130_fd_sc_hd__and4b_1
XTAP_TAPCELL_ROW_10_190 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1447_ net150 net149 div_inst.counter\[3\] div_inst.counter\[2\] VGND VGND VPWR VPWR
+ _0848_ sky130_fd_sc_hd__and4_1
XFILLER_4_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1378_ net307 _0770_ VGND VGND VPWR VPWR _0779_ sky130_fd_sc_hd__xor2_1
XFILLER_55_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_23_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_23_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_23_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_58_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_9_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_14_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_16_227 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1232_ _0639_ _0640_ _0631_ _0638_ VGND VGND VPWR VPWR _0642_ sky130_fd_sc_hd__o211ai_1
XFILLER_49_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_49_140 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_37_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1301_ net7 net302 net6 net135 VGND VGND VPWR VPWR _0702_ sky130_fd_sc_hd__or4_2
X_1094_ _0519_ _0521_ _0522_ VGND VGND VPWR VPWR _0523_ sky130_fd_sc_hd__a21o_1
X_1163_ _0567_ _0580_ VGND VGND VPWR VPWR _0582_ sky130_fd_sc_hd__nand2_1
X_1996_ _0216_ net153 VGND VGND VPWR VPWR _0427_ sky130_fd_sc_hd__nor2_1
XFILLER_18_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_34_56 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_13_208 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_50_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_11_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkload0 clknet_4_0_0_sys_clk VGND VGND VPWR VPWR clkload0/Y sky130_fd_sc_hd__clkinv_2
Xwire126 _0801_ VGND VGND VPWR VPWR net126 sky130_fd_sc_hd__clkbuf_1
XFILLER_59_42 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout270 net271 VGND VGND VPWR VPWR net270 sky130_fd_sc_hd__clkbuf_1
Xfanout281 net8 VGND VGND VPWR VPWR net281 sky130_fd_sc_hd__clkbuf_1
Xfanout292 net293 VGND VGND VPWR VPWR net292 sky130_fd_sc_hd__clkbuf_1
XFILLER_19_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_28_Left_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1781_ _0244_ _0245_ VGND VGND VPWR VPWR _0246_ sky130_fd_sc_hd__and2_1
X_1850_ _0037_ _0495_ _0301_ VGND VGND VPWR VPWR _0302_ sky130_fd_sc_hd__mux2_1
XFILLER_41_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_6_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1215_ _0625_ _0626_ VGND VGND VPWR VPWR _0627_ sky130_fd_sc_hd__nand2_1
X_2195_ clknet_4_4_0_sys_clk _0094_ VGND VGND VPWR VPWR net95 sky130_fd_sc_hd__dfxtp_1
X_1146_ _0565_ _0566_ VGND VGND VPWR VPWR _0567_ sky130_fd_sc_hd__nand2_1
X_1077_ _0508_ net284 _0507_ VGND VGND VPWR VPWR _0005_ sky130_fd_sc_hd__and3b_1
X_1979_ _0203_ net153 VGND VGND VPWR VPWR _0412_ sky130_fd_sc_hd__or2_1
Xhold12 lf_inst.integrator\[22\] VGND VGND VPWR VPWR net322 sky130_fd_sc_hd__dlygate4sd3_1
Xhold34 lf_inst.integrator\[20\] VGND VGND VPWR VPWR net344 sky130_fd_sc_hd__dlygate4sd3_1
Xhold45 net77 VGND VGND VPWR VPWR net355 sky130_fd_sc_hd__dlygate4sd3_1
Xhold56 lf_inst.integrator\[16\] VGND VGND VPWR VPWR net366 sky130_fd_sc_hd__dlygate4sd3_1
Xhold23 net73 VGND VGND VPWR VPWR net333 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_43_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_43_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_6_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_49_425 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_32_325 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1902_ _1013_ net136 VGND VGND VPWR VPWR _0346_ sky130_fd_sc_hd__nor2_1
X_1764_ _0229_ _0201_ _0230_ _0226_ VGND VGND VPWR VPWR _0231_ sky130_fd_sc_hd__a31o_4
X_1833_ net215 net228 _0287_ VGND VGND VPWR VPWR _0290_ sky130_fd_sc_hd__nor3_1
X_1695_ _0169_ VGND VGND VPWR VPWR _0170_ sky130_fd_sc_hd__inv_2
X_2178_ clknet_4_12_0_sys_clk _0078_ VGND VGND VPWR VPWR lf_inst.integrator\[28\]
+ sky130_fd_sc_hd__dfxtp_1
X_2247_ net237 _0146_ VGND VGND VPWR VPWR div_inst.counter\[26\] sky130_fd_sc_hd__dfxtp_1
X_1129_ dco_inst.accumulator\[10\] net68 VGND VGND VPWR VPWR _0552_ sky130_fd_sc_hd__nand2_1
XFILLER_31_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xoutput79 net79 VGND VGND VPWR VPWR debug_dco_word[20] sky130_fd_sc_hd__buf_2
XTAP_TAPCELL_ROW_46_406 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xoutput68 net68 VGND VGND VPWR VPWR debug_dco_word[10] sky130_fd_sc_hd__buf_2
XFILLER_31_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_16_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_19_Right_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_28_Right_28 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1480_ div_inst.counter\[27\] _0866_ VGND VGND VPWR VPWR _0881_ sky130_fd_sc_hd__xnor2_1
XFILLER_21_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2032_ _0254_ net158 VGND VGND VPWR VPWR _0458_ sky130_fd_sc_hd__xnor2_1
XFILLER_39_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_37_Right_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2101_ clknet_4_0_0_sys_clk _0004_ VGND VGND VPWR VPWR dco_inst.accumulator\[0\]
+ sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_60_497 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_46_Right_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1747_ _0213_ _0215_ VGND VGND VPWR VPWR _0216_ sky130_fd_sc_hd__xnor2_2
X_1816_ _0276_ _0273_ VGND VGND VPWR VPWR _0277_ sky130_fd_sc_hd__xor2_2
X_1678_ _1048_ _1049_ _0153_ VGND VGND VPWR VPWR _0155_ sky130_fd_sc_hd__nand3_1
XFILLER_7_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_15_Left_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_55_Right_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_42_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_5_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_44_274 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1532_ _0855_ _0932_ VGND VGND VPWR VPWR _0933_ sky130_fd_sc_hd__nand2b_1
X_1601_ net59 net370 net282 VGND VGND VPWR VPWR _0040_ sky130_fd_sc_hd__mux2_1
X_1463_ div_inst.counter\[23\] div_inst.counter\[22\] net139 _0862_ VGND VGND VPWR
+ VPWR _0864_ sky130_fd_sc_hd__and4_1
X_1394_ div_inst.counter\[26\] _0789_ VGND VGND VPWR VPWR _0795_ sky130_fd_sc_hd__nand2_1
X_2015_ net295 net49 net197 VGND VGND VPWR VPWR _0444_ sky130_fd_sc_hd__o21ai_1
XFILLER_35_296 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_50_288 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_12_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_12_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_2_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_58_333 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_37_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_53_33 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_41_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_5_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_19_247 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_32_288 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_32_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_32_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_27_291 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1515_ _0910_ _0913_ _0915_ VGND VGND VPWR VPWR _0916_ sky130_fd_sc_hd__nand3_1
XTAP_TAPCELL_ROW_10_191 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1446_ net150 net149 div_inst.counter\[2\] VGND VGND VPWR VPWR _0847_ sky130_fd_sc_hd__and3_1
X_1377_ _0772_ _0776_ div_inst.counter\[29\] VGND VGND VPWR VPWR _0778_ sky130_fd_sc_hd__a21oi_1
XFILLER_23_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_48_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_45_Left_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_58_152 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_46_314 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_16_228 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_54_Left_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_24_272 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1231_ dco_inst.accumulator\[23\] net82 VGND VGND VPWR VPWR _0641_ sky130_fd_sc_hd__nand2_1
X_1300_ net302 net135 VGND VGND VPWR VPWR _0701_ sky130_fd_sc_hd__nor2_1
X_1162_ _0565_ _0566_ _0580_ VGND VGND VPWR VPWR _0581_ sky130_fd_sc_hd__a21boi_4
XFILLER_60_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_52_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1093_ _0515_ _0516_ _0514_ VGND VGND VPWR VPWR _0522_ sky130_fd_sc_hd__a21bo_1
X_1995_ _0424_ _0425_ _0426_ VGND VGND VPWR VPWR _0109_ sky130_fd_sc_hd__o21ai_1
XFILLER_20_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1429_ _0809_ _0812_ VGND VGND VPWR VPWR _0830_ sky130_fd_sc_hd__and2b_1
XFILLER_55_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_43_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_28_336 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_28_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_34_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkload1 clknet_4_1_0_sys_clk VGND VGND VPWR VPWR clkload1/Y sky130_fd_sc_hd__clkinv_2
XTAP_TAPCELL_ROW_13_209 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_1_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_59_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_46_100 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout271 net277 VGND VGND VPWR VPWR net271 sky130_fd_sc_hd__buf_1
Xfanout293 net301 VGND VGND VPWR VPWR net293 sky130_fd_sc_hd__dlymetal6s2s_1
XPHY_EDGE_ROW_3_Left_64 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xfanout282 net285 VGND VGND VPWR VPWR net282 sky130_fd_sc_hd__buf_1
Xfanout260 net261 VGND VGND VPWR VPWR net260 sky130_fd_sc_hd__clkbuf_1
XFILLER_34_339 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_34_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1780_ net221 lf_inst.integrator\[26\] VGND VGND VPWR VPWR _0245_ sky130_fd_sc_hd__nand2_1
X_1214_ dco_inst.accumulator\[21\] net80 VGND VGND VPWR VPWR _0626_ sky130_fd_sc_hd__nand2_1
XFILLER_37_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2194_ clknet_4_4_0_sys_clk _0093_ VGND VGND VPWR VPWR net94 sky130_fd_sc_hd__dfxtp_1
X_1145_ _0535_ _0539_ _0553_ _0555_ _0561_ VGND VGND VPWR VPWR _0566_ sky130_fd_sc_hd__a2111o_1
XFILLER_40_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1076_ dco_inst.accumulator\[0\] net234 _0504_ _0506_ VGND VGND VPWR VPWR _0508_
+ sky130_fd_sc_hd__and4_1
X_1978_ net355 net179 _0197_ _0411_ VGND VGND VPWR VPWR _0107_ sky130_fd_sc_hd__a211o_1
XFILLER_20_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold24 net83 VGND VGND VPWR VPWR net334 sky130_fd_sc_hd__dlygate4sd3_1
Xhold46 net85 VGND VGND VPWR VPWR net356 sky130_fd_sc_hd__dlygate4sd3_1
Xhold35 net74 VGND VGND VPWR VPWR net345 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_29_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold57 lf_inst.integrator\[6\] VGND VGND VPWR VPWR net367 sky130_fd_sc_hd__dlygate4sd3_1
Xhold13 lf_inst.integrator\[8\] VGND VGND VPWR VPWR net323 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_45_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_43_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_24_350 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_51_191 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_57_470 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_49_426 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_34_114 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_19_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_19_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1832_ _0287_ _0288_ VGND VGND VPWR VPWR _0289_ sky130_fd_sc_hd__and2_1
X_1901_ _0340_ _0342_ VGND VGND VPWR VPWR _0345_ sky130_fd_sc_hd__nor2_1
X_1763_ net218 lf_inst.integrator\[23\] _0212_ _0214_ VGND VGND VPWR VPWR _0230_ sky130_fd_sc_hd__a211oi_1
XTAP_TAPCELL_ROW_40_370 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1694_ net213 lf_inst.integrator\[16\] VGND VGND VPWR VPWR _0169_ sky130_fd_sc_hd__xnor2_1
X_2246_ net237 _0145_ VGND VGND VPWR VPWR div_inst.counter\[25\] sky130_fd_sc_hd__dfxtp_1
X_2177_ clknet_4_13_0_sys_clk _0077_ VGND VGND VPWR VPWR lf_inst.integrator\[27\]
+ sky130_fd_sc_hd__dfxtp_1
X_1059_ pfd_inst.fb_sync\[1\] _0493_ VGND VGND VPWR VPWR _0497_ sky130_fd_sc_hd__nand2_1
XFILLER_25_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1128_ dco_inst.accumulator\[10\] net68 VGND VGND VPWR VPWR _0551_ sky130_fd_sc_hd__or2_1
XFILLER_21_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xoutput69 net69 VGND VGND VPWR VPWR debug_dco_word[11] sky130_fd_sc_hd__buf_2
XFILLER_56_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_48_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_46_407 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_24_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2100_ clknet_4_2_0_sys_clk _0003_ VGND VGND VPWR VPWR dynamic_ki\[2\] sky130_fd_sc_hd__dfxtp_1
X_2031_ net356 net187 _0457_ net204 _0251_ VGND VGND VPWR VPWR _0114_ sky130_fd_sc_hd__a221o_1
XTAP_TAPCELL_ROW_60_498 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1815_ _0274_ _0275_ VGND VGND VPWR VPWR _0276_ sky130_fd_sc_hd__nand2_1
XFILLER_22_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1746_ _0200_ _0202_ _0206_ _0214_ VGND VGND VPWR VPWR _0215_ sky130_fd_sc_hd__a31o_1
X_1677_ _1049_ _0153_ _1048_ VGND VGND VPWR VPWR _0154_ sky130_fd_sc_hd__a21o_1
X_2229_ net241 _0128_ VGND VGND VPWR VPWR div_inst.counter\[8\] sky130_fd_sc_hd__dfxtp_1
XFILLER_53_264 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_42_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_42_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_305 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_8_176 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_44_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_29_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_44_286 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_32_Left_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1531_ net144 div_inst.counter\[10\] net134 _0852_ div_inst.counter\[11\] VGND VGND
+ VPWR VPWR _0932_ sky130_fd_sc_hd__a41o_1
X_1600_ net282 net329 _0997_ VGND VGND VPWR VPWR _0039_ sky130_fd_sc_hd__a21o_1
XFILLER_8_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1462_ div_inst.counter\[22\] net139 _0862_ VGND VGND VPWR VPWR _0863_ sky130_fd_sc_hd__and3_1
X_1393_ div_inst.counter\[25\] _0793_ VGND VGND VPWR VPWR _0794_ sky130_fd_sc_hd__and2_1
X_2014_ _0436_ _0438_ _0441_ VGND VGND VPWR VPWR _0443_ sky130_fd_sc_hd__and3_1
XFILLER_12_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_58_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1729_ _0198_ _0199_ VGND VGND VPWR VPWR _0200_ sky130_fd_sc_hd__nor2_1
XFILLER_58_345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_37_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_18_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_53_78 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_49_323 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_32_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_27_292 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_17_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_59_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1445_ _0706_ _0711_ _0829_ _0845_ VGND VGND VPWR VPWR _0846_ sky130_fd_sc_hd__nand4b_1
X_1514_ net10 _0912_ _0914_ net9 VGND VGND VPWR VPWR _0915_ sky130_fd_sc_hd__a22o_1
XFILLER_4_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_10_192 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_55_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1376_ div_inst.counter\[29\] _0772_ _0776_ VGND VGND VPWR VPWR _0777_ sky130_fd_sc_hd__and3_1
XFILLER_23_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_48_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_58_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_16_229 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_24_273 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1230_ dco_inst.accumulator\[23\] net82 VGND VGND VPWR VPWR _0640_ sky130_fd_sc_hd__and2_1
XFILLER_37_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_37_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1092_ dco_inst.accumulator\[4\] net93 VGND VGND VPWR VPWR _0521_ sky130_fd_sc_hd__or2_1
X_1161_ _0570_ _0574_ VGND VGND VPWR VPWR _0580_ sky130_fd_sc_hd__and2_1
X_1994_ net331 net181 _0210_ VGND VGND VPWR VPWR _0426_ sky130_fd_sc_hd__a21oi_1
X_1428_ _0786_ net125 _0822_ _0828_ VGND VGND VPWR VPWR _0829_ sky130_fd_sc_hd__and4_1
XFILLER_55_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1359_ _0722_ _0759_ _0754_ _0751_ VGND VGND VPWR VPWR _0760_ sky130_fd_sc_hd__or4bb_1
Xclkload2 clknet_4_2_0_sys_clk VGND VGND VPWR VPWR clkload2/X sky130_fd_sc_hd__clkbuf_8
XTAP_TAPCELL_ROW_21_254 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout294 net300 VGND VGND VPWR VPWR net294 sky130_fd_sc_hd__buf_1
Xfanout272 net273 VGND VGND VPWR VPWR net272 sky130_fd_sc_hd__buf_1
XFILLER_46_112 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xfanout250 net254 VGND VGND VPWR VPWR net250 sky130_fd_sc_hd__clkbuf_2
Xfanout261 net262 VGND VGND VPWR VPWR net261 sky130_fd_sc_hd__buf_1
Xfanout283 net284 VGND VGND VPWR VPWR net283 sky130_fd_sc_hd__clkbuf_1
XFILLER_19_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_6_230 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1213_ dco_inst.accumulator\[21\] net80 VGND VGND VPWR VPWR _0625_ sky130_fd_sc_hd__or2_1
XFILLER_52_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_1_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2193_ clknet_4_1_0_sys_clk _0092_ VGND VGND VPWR VPWR net93 sky130_fd_sc_hd__dfxtp_1
X_1075_ dco_inst.accumulator\[0\] net233 _0504_ _0506_ VGND VGND VPWR VPWR _0507_
+ sky130_fd_sc_hd__a22o_1
X_1144_ _0552_ _0559_ _0564_ _0553_ _0560_ VGND VGND VPWR VPWR _0565_ sky130_fd_sc_hd__o221a_1
XFILLER_60_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_43_390 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1977_ _0409_ _0410_ VGND VGND VPWR VPWR _0411_ sky130_fd_sc_hd__nor2_1
XFILLER_20_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold36 lf_inst.integrator\[26\] VGND VGND VPWR VPWR net346 sky130_fd_sc_hd__dlygate4sd3_1
Xhold14 lf_inst.integrator\[30\] VGND VGND VPWR VPWR net324 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_45_13 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold47 lf_inst.integrator\[24\] VGND VGND VPWR VPWR net357 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_28_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xhold25 lf_inst.integrator\[7\] VGND VGND VPWR VPWR net335 sky130_fd_sc_hd__dlygate4sd3_1
Xhold58 net68 VGND VGND VPWR VPWR net368 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_45_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_16_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_6_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_200 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_59_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_57_471 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_49_427 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_34_126 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_19_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_40_371 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1831_ net212 net228 net230 VGND VGND VPWR VPWR _0288_ sky130_fd_sc_hd__o21ai_1
X_1900_ net255 net63 net372 net173 _0344_ VGND VGND VPWR VPWR _0096_ sky130_fd_sc_hd__a221o_1
X_1762_ _0182_ _0228_ _0192_ _0183_ VGND VGND VPWR VPWR _0229_ sky130_fd_sc_hd__or4_4
X_1693_ _0166_ _0167_ VGND VGND VPWR VPWR _0168_ sky130_fd_sc_hd__nand2_1
X_2176_ clknet_4_14_0_sys_clk _0076_ VGND VGND VPWR VPWR lf_inst.integrator\[26\]
+ sky130_fd_sc_hd__dfxtp_1
X_2245_ net238 _0144_ VGND VGND VPWR VPWR div_inst.counter\[24\] sky130_fd_sc_hd__dfxtp_1
XFILLER_25_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1058_ lf_inst.integrator\[3\] VGND VGND VPWR VPWR _0496_ sky130_fd_sc_hd__inv_2
X_1127_ net287 _0549_ _0550_ VGND VGND VPWR VPWR _0013_ sky130_fd_sc_hd__and3_1
XFILLER_15_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_15_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_31_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_1_Right_1 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_56_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_46_408 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_16_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_54_452 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_4_3_0_sys_clk clknet_0_sys_clk VGND VGND VPWR VPWR clknet_4_3_0_sys_clk sky130_fd_sc_hd__clkbuf_8
X_2030_ _0454_ _0456_ VGND VGND VPWR VPWR _0457_ sky130_fd_sc_hd__xor2_1
XTAP_TAPCELL_ROW_60_499 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_60_488 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1814_ net222 lf_inst.integrator\[30\] VGND VGND VPWR VPWR _0275_ sky130_fd_sc_hd__or2_1
X_1745_ lf_inst.integrator\[20\] lf_inst.integrator\[21\] net218 VGND VGND VPWR VPWR
+ _0214_ sky130_fd_sc_hd__o21a_1
XFILLER_15_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1676_ _1029_ _1036_ _1037_ _1042_ VGND VGND VPWR VPWR _0153_ sky130_fd_sc_hd__or4_1
XFILLER_53_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2228_ net244 _0127_ VGND VGND VPWR VPWR div_inst.counter\[7\] sky130_fd_sc_hd__dfxtp_1
XFILLER_38_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_26_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2159_ clknet_4_1_0_sys_clk _0059_ VGND VGND VPWR VPWR lf_inst.integrator\[9\] sky130_fd_sc_hd__dfxtp_1
XFILLER_53_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_42_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_13_118 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_5_317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_8_177 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_44_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_44_210 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_32_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_8_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_12_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_59_6 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1530_ net5 _0928_ _0929_ _0925_ _0926_ VGND VGND VPWR VPWR _0931_ sky130_fd_sc_hd__o2111a_1
XFILLER_4_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1392_ _0769_ _0792_ VGND VGND VPWR VPWR _0793_ sky130_fd_sc_hd__nor2_1
X_1461_ div_inst.counter\[20\] net130 net138 _0860_ VGND VGND VPWR VPWR _0862_ sky130_fd_sc_hd__and4_1
X_2013_ _0436_ _0438_ _0441_ VGND VGND VPWR VPWR _0442_ sky130_fd_sc_hd__a21oi_1
XFILLER_35_210 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_35_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1728_ net216 lf_inst.integrator\[20\] VGND VGND VPWR VPWR _0199_ sky130_fd_sc_hd__and2_1
XFILLER_2_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_58_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_5_158 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1659_ lf_inst.integrator\[12\] net169 VGND VGND VPWR VPWR _1035_ sky130_fd_sc_hd__nand2_1
XFILLER_41_202 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_26_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_41_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_41_268 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_5_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_49_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_27_293 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_57_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_10_193 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1444_ _0714_ _0844_ _0750_ _0843_ VGND VGND VPWR VPWR _0845_ sky130_fd_sc_hd__and4bb_1
X_1513_ div_inst.counter\[16\] net131 VGND VGND VPWR VPWR _0914_ sky130_fd_sc_hd__xnor2_1
XFILLER_4_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1375_ net307 _0770_ net22 VGND VGND VPWR VPWR _0776_ sky130_fd_sc_hd__o21ai_1
XFILLER_55_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_55_305 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_23_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_23_257 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_48_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_24_274 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_1_194 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_49_198 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1091_ _0519_ VGND VGND VPWR VPWR _0520_ sky130_fd_sc_hd__inv_2
X_1160_ _0577_ _0578_ VGND VGND VPWR VPWR _0579_ sky130_fd_sc_hd__nand2_1
X_1993_ _0412_ _0418_ _0423_ net196 VGND VGND VPWR VPWR _0425_ sky130_fd_sc_hd__a31o_1
X_1358_ _0757_ _0718_ _0753_ VGND VGND VPWR VPWR _0759_ sky130_fd_sc_hd__or3b_1
XFILLER_28_316 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1427_ _0823_ _0826_ _0827_ VGND VGND VPWR VPWR _0828_ sky130_fd_sc_hd__and3_1
X_1289_ _0684_ _0689_ _0690_ VGND VGND VPWR VPWR _0691_ sky130_fd_sc_hd__a21oi_1
XFILLER_28_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkload3 clknet_4_3_0_sys_clk VGND VGND VPWR VPWR clkload3/Y sky130_fd_sc_hd__bufinv_16
XTAP_TAPCELL_ROW_21_255 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout240 net246 VGND VGND VPWR VPWR net240 sky130_fd_sc_hd__buf_1
Xfanout295 net300 VGND VGND VPWR VPWR net295 sky130_fd_sc_hd__buf_1
Xfanout273 net276 VGND VGND VPWR VPWR net273 sky130_fd_sc_hd__clkbuf_1
Xfanout251 net254 VGND VGND VPWR VPWR net251 sky130_fd_sc_hd__buf_1
Xfanout284 net285 VGND VGND VPWR VPWR net284 sky130_fd_sc_hd__dlymetal6s2s_1
Xfanout262 net279 VGND VGND VPWR VPWR net262 sky130_fd_sc_hd__buf_1
XTAP_TAPCELL_ROW_12_200 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_6_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_6_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1212_ net294 _0623_ _0624_ VGND VGND VPWR VPWR _0024_ sky130_fd_sc_hd__and3_1
XFILLER_37_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2192_ clknet_4_1_0_sys_clk _0091_ VGND VGND VPWR VPWR net92 sky130_fd_sc_hd__dfxtp_1
XFILLER_52_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_37_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1074_ dco_inst.accumulator\[1\] net78 VGND VGND VPWR VPWR _0506_ sky130_fd_sc_hd__nand2_1
X_1143_ _0548_ _0554_ _0561_ VGND VGND VPWR VPWR _0564_ sky130_fd_sc_hd__a21o_1
XTAP_TAPCELL_ROW_43_391 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1976_ _0400_ _0404_ _0408_ net194 VGND VGND VPWR VPWR _0410_ sky130_fd_sc_hd__a31o_1
Xhold59 net82 VGND VGND VPWR VPWR net369 sky130_fd_sc_hd__dlygate4sd3_1
Xhold15 lf_inst.integrator\[31\] VGND VGND VPWR VPWR net325 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_45_25 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold26 pfd_inst.ref_sync\[1\] VGND VGND VPWR VPWR net336 sky130_fd_sc_hd__dlygate4sd3_1
Xhold37 pfd_inst.state\[2\] VGND VGND VPWR VPWR net347 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_28_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold48 unlock_timer\[1\] VGND VGND VPWR VPWR net358 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_3_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_10_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_59_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_57_472 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_34_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1761_ _0198_ _0227_ _0199_ _0206_ VGND VGND VPWR VPWR _0228_ sky130_fd_sc_hd__or4b_1
XTAP_TAPCELL_ROW_40_372 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1830_ net229 _0286_ VGND VGND VPWR VPWR _0287_ sky130_fd_sc_hd__nand2_1
X_1692_ _1049_ _0164_ _0158_ _1047_ VGND VGND VPWR VPWR _0167_ sky130_fd_sc_hd__o211a_1
X_2175_ clknet_4_11_0_sys_clk _0075_ VGND VGND VPWR VPWR lf_inst.integrator\[25\]
+ sky130_fd_sc_hd__dfxtp_1
X_2244_ net238 _0143_ VGND VGND VPWR VPWR div_inst.counter\[23\] sky130_fd_sc_hd__dfxtp_1
X_1126_ _0542_ _0544_ _0546_ _0547_ VGND VGND VPWR VPWR _0550_ sky130_fd_sc_hd__a211o_1
X_1057_ lf_inst.integrator\[1\] VGND VGND VPWR VPWR _0495_ sky130_fd_sc_hd__inv_2
XFILLER_31_16 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1959_ _0393_ _0394_ VGND VGND VPWR VPWR _0395_ sky130_fd_sc_hd__xor2_1
XTAP_TAPCELL_ROW_54_453 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_409 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_8_348 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_4_7_0_sys_clk clknet_0_sys_clk VGND VGND VPWR VPWR clknet_4_7_0_sys_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_30_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_60_489 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1744_ _0211_ _0212_ VGND VGND VPWR VPWR _0213_ sky130_fd_sc_hd__nor2_1
X_1813_ net222 lf_inst.integrator\[30\] VGND VGND VPWR VPWR _0274_ sky130_fd_sc_hd__nand2_1
XFILLER_30_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_7_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1675_ lf_inst.integrator\[13\] _1041_ _1035_ VGND VGND VPWR VPWR _1049_ sky130_fd_sc_hd__a21boi_1
XPHY_EDGE_ROW_15_Right_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2227_ net243 _0126_ VGND VGND VPWR VPWR div_inst.counter\[6\] sky130_fd_sc_hd__dfxtp_1
XFILLER_38_263 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2158_ clknet_4_13_0_sys_clk _0058_ VGND VGND VPWR VPWR pfd_inst.ref_sync\[2\] sky130_fd_sc_hd__dfxtp_1
XPHY_EDGE_ROW_24_Right_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1109_ dco_inst.accumulator\[7\] net96 VGND VGND VPWR VPWR _0535_ sky130_fd_sc_hd__nand2_1
X_2089_ net256 _0889_ net101 net113 VGND VGND VPWR VPWR _0143_ sky130_fd_sc_hd__and4bb_1
XTAP_TAPCELL_ROW_51_434 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_42_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_33_Right_33 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_5_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_29_252 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_8_178 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_42_Right_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_51_Right_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_12_152 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_12_174 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1391_ net309 _0768_ VGND VGND VPWR VPWR _0792_ sky130_fd_sc_hd__and2_1
X_1460_ net130 net138 _0860_ VGND VGND VPWR VPWR _0861_ sky130_fd_sc_hd__nand3_2
XPHY_EDGE_ROW_60_Right_60 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2012_ _0439_ _0440_ VGND VGND VPWR VPWR _0441_ sky130_fd_sc_hd__nand2b_1
XFILLER_35_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_50_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1727_ net216 lf_inst.integrator\[20\] VGND VGND VPWR VPWR _0198_ sky130_fd_sc_hd__nor2_1
XFILLER_12_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1658_ net327 net174 _1033_ net200 _1034_ VGND VGND VPWR VPWR _0061_ sky130_fd_sc_hd__a221o_1
XTAP_TAPCELL_ROW_5_159 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1589_ _0882_ _0988_ _0989_ _0878_ VGND VGND VPWR VPWR _0990_ sky130_fd_sc_hd__o211a_1
XFILLER_53_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_41_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_41_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_26_211 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_27_294 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_17_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1512_ net10 _0912_ VGND VGND VPWR VPWR _0913_ sky130_fd_sc_hd__or2_1
X_1443_ _0727_ _0729_ _0746_ _0842_ VGND VGND VPWR VPWR _0844_ sky130_fd_sc_hd__or4b_1
X_1374_ div_inst.counter\[31\] _0774_ VGND VGND VPWR VPWR _0775_ sky130_fd_sc_hd__nand2_1
XFILLER_4_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_55_317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_23_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_23_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_24_275 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_14_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_13_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_22_291 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_49_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_49_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1090_ dco_inst.accumulator\[4\] net93 VGND VGND VPWR VPWR _0519_ sky130_fd_sc_hd__nand2_1
Xclkload10 clknet_4_11_0_sys_clk VGND VGND VPWR VPWR clkload10/Y sky130_fd_sc_hd__clkinvlp_4
X_1992_ _0420_ _0421_ _0422_ VGND VGND VPWR VPWR _0424_ sky130_fd_sc_hd__and3_1
XPHY_EDGE_ROW_41_Left_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_15_220 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1288_ net243 net91 VGND VGND VPWR VPWR _0690_ sky130_fd_sc_hd__xnor2_1
XPHY_EDGE_ROW_50_Left_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1357_ _0756_ _0757_ VGND VGND VPWR VPWR _0758_ sky130_fd_sc_hd__nor2_1
X_1426_ div_inst.counter\[16\] _0825_ VGND VGND VPWR VPWR _0827_ sky130_fd_sc_hd__nand2_1
XFILLER_55_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_38_356 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_34_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_11_228 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkload4 clknet_4_4_0_sys_clk VGND VGND VPWR VPWR clkload4/X sky130_fd_sc_hd__clkbuf_8
XTAP_TAPCELL_ROW_21_256 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_59_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout274 net276 VGND VGND VPWR VPWR net274 sky130_fd_sc_hd__buf_1
Xfanout241 net242 VGND VGND VPWR VPWR net241 sky130_fd_sc_hd__buf_1
Xfanout230 lf_inst.sample_en VGND VGND VPWR VPWR net230 sky130_fd_sc_hd__buf_1
Xfanout263 net265 VGND VGND VPWR VPWR net263 sky130_fd_sc_hd__buf_1
Xfanout252 net254 VGND VGND VPWR VPWR net252 sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_46_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_34_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xfanout296 net297 VGND VGND VPWR VPWR net296 sky130_fd_sc_hd__buf_1
Xfanout285 net293 VGND VGND VPWR VPWR net285 sky130_fd_sc_hd__clkbuf_2
XFILLER_54_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_24_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_12_201 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_6_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1211_ _0619_ _0622_ VGND VGND VPWR VPWR _0624_ sky130_fd_sc_hd__or2_1
XFILLER_37_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2191_ clknet_4_0_0_sys_clk _0090_ VGND VGND VPWR VPWR net89 sky130_fd_sc_hd__dfxtp_1
X_1142_ _0562_ _0563_ VGND VGND VPWR VPWR _0015_ sky130_fd_sc_hd__nor2_1
XFILLER_60_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_52_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_37_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1073_ dco_inst.accumulator\[1\] net78 VGND VGND VPWR VPWR _0505_ sky130_fd_sc_hd__and2_1
X_1975_ _0400_ _0404_ _0408_ VGND VGND VPWR VPWR _0409_ sky130_fd_sc_hd__a21oi_1
XFILLER_20_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold27 pfd_inst.ref_sync\[2\] VGND VGND VPWR VPWR net337 sky130_fd_sc_hd__dlygate4sd3_1
Xhold16 dco_inst.accumulator\[0\] VGND VGND VPWR VPWR net326 sky130_fd_sc_hd__dlygate4sd3_1
Xhold38 unlock_timer\[0\] VGND VGND VPWR VPWR net348 sky130_fd_sc_hd__dlygate4sd3_1
X_1409_ div_inst.counter\[23\] _0802_ _0805_ div_inst.counter\[22\] VGND VGND VPWR
+ VPWR _0810_ sky130_fd_sc_hd__o22ai_1
XFILLER_45_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xhold49 net94 VGND VGND VPWR VPWR net359 sky130_fd_sc_hd__dlygate4sd3_1
XPHY_EDGE_ROW_7_Left_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_3_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_3_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_19_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_57_473 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_27_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_15_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1760_ _0213_ _0219_ VGND VGND VPWR VPWR _0227_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_40_373 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_30_345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1691_ _0165_ _1037_ _1029_ VGND VGND VPWR VPWR _0166_ sky130_fd_sc_hd__or3_4
X_2174_ clknet_4_12_0_sys_clk _0074_ VGND VGND VPWR VPWR lf_inst.integrator\[24\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_25_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1125_ _0546_ _0547_ _0542_ _0544_ VGND VGND VPWR VPWR _0549_ sky130_fd_sc_hd__o211ai_1
X_2243_ net238 _0142_ VGND VGND VPWR VPWR div_inst.counter\[22\] sky130_fd_sc_hd__dfxtp_1
XFILLER_33_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1056_ net13 VGND VGND VPWR VPWR _0494_ sky130_fd_sc_hd__inv_2
XFILLER_31_28 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1958_ net167 _0171_ _0385_ _0389_ VGND VGND VPWR VPWR _0394_ sky130_fd_sc_hd__o22ai_1
X_1889_ _0333_ _0334_ VGND VGND VPWR VPWR _0335_ sky130_fd_sc_hd__xnor2_1
XFILLER_56_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_54_454 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_47_297 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_47_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_15_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1743_ net219 lf_inst.integrator\[22\] VGND VGND VPWR VPWR _0212_ sky130_fd_sc_hd__and2_1
X_1812_ _0269_ _0263_ _0268_ _0257_ VGND VGND VPWR VPWR _0273_ sky130_fd_sc_hd__o211a_1
XFILLER_30_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1674_ net210 lf_inst.integrator\[14\] VGND VGND VPWR VPWR _1048_ sky130_fd_sc_hd__xnor2_2
X_2226_ net243 _0125_ VGND VGND VPWR VPWR div_inst.counter\[5\] sky130_fd_sc_hd__dfxtp_1
X_2157_ clknet_4_7_0_sys_clk _0057_ VGND VGND VPWR VPWR pfd_inst.ref_sync\[1\] sky130_fd_sc_hd__dfxtp_1
X_1108_ _0533_ _0534_ VGND VGND VPWR VPWR _0010_ sky130_fd_sc_hd__nor2_1
X_2088_ net256 _0892_ net101 net113 VGND VGND VPWR VPWR _0142_ sky130_fd_sc_hd__and4bb_1
XFILLER_13_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_51_435 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_29_264 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_8_179 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_16_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_32_60 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_12_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1390_ _0771_ _0787_ div_inst.counter\[27\] VGND VGND VPWR VPWR _0791_ sky130_fd_sc_hd__or3b_1
X_2011_ _0233_ net156 VGND VGND VPWR VPWR _0440_ sky130_fd_sc_hd__nand2_1
X_1726_ net319 net178 _0196_ _0197_ VGND VGND VPWR VPWR _0069_ sky130_fd_sc_hd__a211o_1
X_1657_ net250 net35 VGND VGND VPWR VPWR _1034_ sky130_fd_sc_hd__and2_1
X_1588_ net22 _0874_ _0881_ net307 VGND VGND VPWR VPWR _0989_ sky130_fd_sc_hd__o22a_1
X_2209_ clknet_4_10_0_sys_clk _0108_ VGND VGND VPWR VPWR net79 sky130_fd_sc_hd__dfxtp_1
XFILLER_41_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_26_223 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_49_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_36_Left_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_17_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_40_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_27_295 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1442_ _0756_ _0760_ VGND VGND VPWR VPWR _0843_ sky130_fd_sc_hd__nor2_1
X_1511_ net131 _0859_ _0911_ VGND VGND VPWR VPWR _0912_ sky130_fd_sc_hd__a21o_1
XFILLER_55_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_4_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1373_ net25 _0773_ VGND VGND VPWR VPWR _0774_ sky130_fd_sc_hd__xor2_1
XTAP_TAPCELL_ROW_18_240 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_23_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_31_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_58_112 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1709_ _0180_ _0181_ VGND VGND VPWR VPWR _0182_ sky130_fd_sc_hd__nand2_2
XFILLER_46_329 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_24_276 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_37_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_60_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_15_221 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1991_ _0421_ _0422_ VGND VGND VPWR VPWR _0423_ sky130_fd_sc_hd__nand2_1
Xclkload11 clknet_4_12_0_sys_clk VGND VGND VPWR VPWR clkload11/Y sky130_fd_sc_hd__clkinv_4
XFILLER_9_263 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_9_296 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1425_ div_inst.counter\[17\] _0819_ _0825_ div_inst.counter\[16\] VGND VGND VPWR
+ VPWR _0826_ sky130_fd_sc_hd__o22a_1
X_1287_ net299 _0688_ _0689_ VGND VGND VPWR VPWR _0034_ sky130_fd_sc_hd__and3_1
XFILLER_55_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_55_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1356_ div_inst.counter\[11\] _0717_ VGND VGND VPWR VPWR _0757_ sky130_fd_sc_hd__and2_1
XTAP_TAPCELL_ROW_38_357 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_28_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_18_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkload5 clknet_4_5_0_sys_clk VGND VGND VPWR VPWR clkload5/Y sky130_fd_sc_hd__clkinv_2
XTAP_TAPCELL_ROW_21_257 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_59_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout275 net276 VGND VGND VPWR VPWR net275 sky130_fd_sc_hd__clkbuf_1
Xfanout264 net265 VGND VGND VPWR VPWR net264 sky130_fd_sc_hd__clkbuf_1
Xfanout242 net244 VGND VGND VPWR VPWR net242 sky130_fd_sc_hd__clkbuf_1
Xfanout220 net226 VGND VGND VPWR VPWR net220 sky130_fd_sc_hd__buf_1
Xfanout297 net298 VGND VGND VPWR VPWR net297 sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_29_302 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout286 net292 VGND VGND VPWR VPWR net286 sky130_fd_sc_hd__clkbuf_2
Xfanout231 dynamic_kp\[2\] VGND VGND VPWR VPWR net231 sky130_fd_sc_hd__buf_1
Xfanout253 net254 VGND VGND VPWR VPWR net253 sky130_fd_sc_hd__clkbuf_1
XFILLER_27_351 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_24_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_12_202 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_34_7 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_6_277 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1210_ _0619_ _0622_ VGND VGND VPWR VPWR _0623_ sky130_fd_sc_hd__nand2_1
XFILLER_37_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_27_6 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1072_ dco_inst.accumulator\[1\] net78 VGND VGND VPWR VPWR _0504_ sky130_fd_sc_hd__or2_1
X_2190_ clknet_4_3_0_sys_clk _0089_ VGND VGND VPWR VPWR net78 sky130_fd_sc_hd__dfxtp_1
X_1141_ _0552_ _0558_ _0561_ net255 VGND VGND VPWR VPWR _0563_ sky130_fd_sc_hd__a31o_1
XFILLER_45_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1974_ _0406_ _0407_ VGND VGND VPWR VPWR _0408_ sky130_fd_sc_hd__or2_1
XTAP_TAPCELL_ROW_35_338 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_23_Left_84 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_20_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xhold39 lf_inst.integrator\[25\] VGND VGND VPWR VPWR net349 sky130_fd_sc_hd__dlygate4sd3_1
Xhold28 net89 VGND VGND VPWR VPWR net338 sky130_fd_sc_hd__dlygate4sd3_1
X_1408_ div_inst.counter\[23\] _0802_ _0805_ div_inst.counter\[22\] _0808_ VGND VGND
+ VPWR VPWR _0809_ sky130_fd_sc_hd__a221o_1
Xhold17 lf_inst.integrator\[11\] VGND VGND VPWR VPWR net327 sky130_fd_sc_hd__dlygate4sd3_1
X_1339_ _0693_ _0739_ VGND VGND VPWR VPWR _0740_ sky130_fd_sc_hd__nor2_1
XFILLER_51_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_3_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_57_474 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_30_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1690_ _0164_ _1042_ _1036_ VGND VGND VPWR VPWR _0165_ sky130_fd_sc_hd__or3_4
X_2242_ net238 _0141_ VGND VGND VPWR VPWR div_inst.counter\[21\] sky130_fd_sc_hd__dfxtp_1
X_2173_ clknet_4_11_0_sys_clk _0073_ VGND VGND VPWR VPWR lf_inst.integrator\[23\]
+ sky130_fd_sc_hd__dfxtp_1
X_1055_ pfd_inst.fb_sync\[2\] VGND VGND VPWR VPWR _0493_ sky130_fd_sc_hd__inv_2
X_1124_ dco_inst.accumulator\[9\] net98 VGND VGND VPWR VPWR _0548_ sky130_fd_sc_hd__nand2_1
XFILLER_33_184 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1957_ _0177_ _0392_ VGND VGND VPWR VPWR _0393_ sky130_fd_sc_hd__xnor2_1
XFILLER_21_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1888_ lf_inst.integrator\[6\] net162 _0330_ VGND VGND VPWR VPWR _0334_ sky130_fd_sc_hd__a21oi_1
XFILLER_56_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_56_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_56_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_54_455 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_24_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_16_118 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_16_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_47_210 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_45_400 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1811_ net321 net185 _0271_ net205 _0272_ VGND VGND VPWR VPWR _0079_ sky130_fd_sc_hd__a221o_1
X_1742_ net218 lf_inst.integrator\[22\] VGND VGND VPWR VPWR _0211_ sky130_fd_sc_hd__nor2_1
X_1673_ net210 lf_inst.integrator\[14\] VGND VGND VPWR VPWR _1047_ sky130_fd_sc_hd__nand2_1
XFILLER_7_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2225_ net243 _0124_ VGND VGND VPWR VPWR div_inst.counter\[4\] sky130_fd_sc_hd__dfxtp_1
XFILLER_38_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_51_436 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2156_ clknet_4_7_0_sys_clk _0056_ VGND VGND VPWR VPWR pfd_inst.ref_sync\[0\] sky130_fd_sc_hd__dfxtp_1
XFILLER_26_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_5_Right_5 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1107_ _0525_ _0531_ _0532_ net255 VGND VGND VPWR VPWR _0534_ sky130_fd_sc_hd__a31o_1
X_2087_ net256 _0894_ net101 net113 VGND VGND VPWR VPWR _0141_ sky130_fd_sc_hd__and4bb_1
XPHY_EDGE_ROW_10_Left_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2010_ _0233_ net156 VGND VGND VPWR VPWR _0439_ sky130_fd_sc_hd__nor2_1
X_1725_ net263 net43 VGND VGND VPWR VPWR _0197_ sky130_fd_sc_hd__and2_1
X_1587_ _0887_ _0983_ _0987_ VGND VGND VPWR VPWR _0988_ sky130_fd_sc_hd__a21boi_1
X_1656_ _1032_ VGND VGND VPWR VPWR _1033_ sky130_fd_sc_hd__inv_2
X_2208_ clknet_4_8_0_sys_clk _0107_ VGND VGND VPWR VPWR net77 sky130_fd_sc_hd__dfxtp_1
XFILLER_37_28 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_26_235 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2139_ clknet_4_4_0_sys_clk _0042_ VGND VGND VPWR VPWR lf_inst.integrator\[6\] sky130_fd_sc_hd__dfxtp_1
XFILLER_53_16 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_17_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_17_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_40_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1441_ net150 net312 _0734_ _0742_ VGND VGND VPWR VPWR _0842_ sky130_fd_sc_hd__o211a_1
X_1510_ div_inst.counter\[16\] net131 div_inst.counter\[17\] VGND VGND VPWR VPWR _0911_
+ sky130_fd_sc_hd__a21oi_1
XFILLER_4_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1372_ net24 net22 net21 _0770_ VGND VGND VPWR VPWR _0773_ sky130_fd_sc_hd__or4_1
XTAP_TAPCELL_ROW_18_241 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_23_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1708_ net212 lf_inst.integrator\[18\] VGND VGND VPWR VPWR _0181_ sky130_fd_sc_hd__nand2_1
XFILLER_48_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1639_ net265 net229 VGND VGND VPWR VPWR _1018_ sky130_fd_sc_hd__or2_2
XFILLER_39_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_24_277 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_13_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_14_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_13_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_49_124 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_49_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_60_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1990_ _0208_ net154 VGND VGND VPWR VPWR _0422_ sky130_fd_sc_hd__nand2_1
XFILLER_45_352 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_13_260 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_15_222 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkload12 clknet_4_13_0_sys_clk VGND VGND VPWR VPWR clkload12/Y sky130_fd_sc_hd__clkinvlp_4
X_1355_ net143 net135 _0712_ VGND VGND VPWR VPWR _0756_ sky130_fd_sc_hd__and3_1
X_1424_ _0763_ _0824_ VGND VGND VPWR VPWR _0825_ sky130_fd_sc_hd__and2b_1
X_1286_ _0672_ _0678_ _0680_ _0686_ _0679_ VGND VGND VPWR VPWR _0689_ sky130_fd_sc_hd__a311o_1
XFILLER_55_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_38_358 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_18_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_34_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_21_258 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkload6 clknet_4_6_0_sys_clk VGND VGND VPWR VPWR clkload6/Y sky130_fd_sc_hd__clkinv_2
Xfanout243 net244 VGND VGND VPWR VPWR net243 sky130_fd_sc_hd__dlymetal6s2s_1
Xfanout276 net277 VGND VGND VPWR VPWR net276 sky130_fd_sc_hd__buf_1
XFILLER_46_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout221 net225 VGND VGND VPWR VPWR net221 sky130_fd_sc_hd__clkbuf_2
Xfanout298 net299 VGND VGND VPWR VPWR net298 sky130_fd_sc_hd__buf_1
Xfanout265 net268 VGND VGND VPWR VPWR net265 sky130_fd_sc_hd__dlymetal6s2s_1
XTAP_TAPCELL_ROW_29_303 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout232 dynamic_kp\[2\] VGND VGND VPWR VPWR net232 sky130_fd_sc_hd__buf_1
Xfanout210 net214 VGND VGND VPWR VPWR net210 sky130_fd_sc_hd__buf_6
Xfanout254 net262 VGND VGND VPWR VPWR net254 sky130_fd_sc_hd__clkbuf_2
Xfanout287 net292 VGND VGND VPWR VPWR net287 sky130_fd_sc_hd__buf_1
XFILLER_42_344 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_24_62 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_12_203 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_6_289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_37_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_37_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_1_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1071_ net326 net233 _0503_ VGND VGND VPWR VPWR _0004_ sky130_fd_sc_hd__a21oi_1
X_1140_ _0552_ _0558_ _0561_ VGND VGND VPWR VPWR _0562_ sky130_fd_sc_hd__a21oi_1
XFILLER_60_174 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_60_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1973_ _0193_ _0194_ net160 VGND VGND VPWR VPWR _0407_ sky130_fd_sc_hd__a21oi_1
XTAP_TAPCELL_ROW_35_339 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_33_322 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1338_ net312 net12 VGND VGND VPWR VPWR _0739_ sky130_fd_sc_hd__and2_1
Xhold29 lf_inst.integrator\[2\] VGND VGND VPWR VPWR net339 sky130_fd_sc_hd__dlygate4sd3_1
Xhold18 lf_inst.integrator\[1\] VGND VGND VPWR VPWR net328 sky130_fd_sc_hd__dlygate4sd3_1
X_1407_ div_inst.counter\[21\] net129 _0806_ VGND VGND VPWR VPWR _0808_ sky130_fd_sc_hd__and3_1
X_1269_ _0659_ _0666_ _0668_ _0663_ VGND VGND VPWR VPWR _0674_ sky130_fd_sc_hd__o211a_1
XFILLER_3_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_59_241 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_57_475 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_42_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_35_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_15_322 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_15_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_15_344 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_51_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2172_ clknet_4_11_0_sys_clk _0072_ VGND VGND VPWR VPWR lf_inst.integrator\[22\]
+ sky130_fd_sc_hd__dfxtp_1
X_2241_ net238 _0140_ VGND VGND VPWR VPWR div_inst.counter\[20\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_48_420 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1054_ net316 VGND VGND VPWR VPWR _0492_ sky130_fd_sc_hd__inv_2
X_1123_ dco_inst.accumulator\[9\] net98 VGND VGND VPWR VPWR _0547_ sky130_fd_sc_hd__and2_1
XFILLER_33_196 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1956_ net232 net166 _1041_ VGND VGND VPWR VPWR _0392_ sky130_fd_sc_hd__a21bo_1
X_1887_ lf_inst.integrator\[7\] net162 VGND VGND VPWR VPWR _0333_ sky130_fd_sc_hd__xor2_1
XFILLER_56_277 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_56_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_54_456 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_24_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_24_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_12_336 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_12_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_47_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_45_401 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_15_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1810_ net272 net54 VGND VGND VPWR VPWR _0272_ sky130_fd_sc_hd__and2_1
X_1741_ net373 net181 _0209_ _0210_ VGND VGND VPWR VPWR _0071_ sky130_fd_sc_hd__a211o_1
XFILLER_30_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_7_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_7_10 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1672_ lf_inst.integrator\[13\] net175 _1045_ net201 _1046_ VGND VGND VPWR VPWR _0063_
+ sky130_fd_sc_hd__a221o_1
X_2224_ net245 _0123_ VGND VGND VPWR VPWR div_inst.counter\[3\] sky130_fd_sc_hd__dfxtp_1
XFILLER_38_288 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_38_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2155_ clknet_4_7_0_sys_clk _0002_ VGND VGND VPWR VPWR pfd_inst.state\[2\] sky130_fd_sc_hd__dfxtp_1
X_1106_ _0525_ _0532_ _0531_ VGND VGND VPWR VPWR _0533_ sky130_fd_sc_hd__a21oi_1
XFILLER_53_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_51_437 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_42_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_42_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2086_ net260 _0896_ net101 net113 VGND VGND VPWR VPWR _0140_ sky130_fd_sc_hd__and4bb_1
XFILLER_21_133 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1939_ _0375_ _0377_ VGND VGND VPWR VPWR _0378_ sky130_fd_sc_hd__nand2b_1
Xclkbuf_4_13_0_sys_clk clknet_0_sys_clk VGND VGND VPWR VPWR clknet_4_13_0_sys_clk
+ sky130_fd_sc_hd__clkbuf_8
XFILLER_29_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_8_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_8_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_11_Right_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_12_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_16_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_32_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_4_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_20_Right_20 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_7_170 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_35_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_35_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1724_ net193 _0195_ VGND VGND VPWR VPWR _0196_ sky130_fd_sc_hd__nor2_1
X_1586_ net20 _0880_ _0884_ net19 _0986_ VGND VGND VPWR VPWR _0987_ sky130_fd_sc_hd__o221a_1
X_1655_ _1028_ _1031_ VGND VGND VPWR VPWR _1032_ sky130_fd_sc_hd__xnor2_1
X_2069_ net274 _0961_ net110 net122 VGND VGND VPWR VPWR _0123_ sky130_fd_sc_hd__and4bb_1
X_2207_ clknet_4_8_0_sys_clk _0106_ VGND VGND VPWR VPWR net76 sky130_fd_sc_hd__dfxtp_1
XFILLER_26_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2138_ clknet_4_4_0_sys_clk _0041_ VGND VGND VPWR VPWR lf_inst.integrator\[5\] sky130_fd_sc_hd__dfxtp_1
XFILLER_57_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_49_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_1_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_27_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_27_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_17_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_43_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1440_ _0762_ _0829_ _0834_ _0840_ VGND VGND VPWR VPWR _0841_ sky130_fd_sc_hd__a211o_1
XFILLER_4_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_4_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1371_ net22 net307 _0770_ VGND VGND VPWR VPWR _0772_ sky130_fd_sc_hd__or3_1
X_1707_ net212 lf_inst.integrator\[18\] VGND VGND VPWR VPWR _0180_ sky130_fd_sc_hd__or2_1
X_1638_ net265 net229 VGND VGND VPWR VPWR _1017_ sky130_fd_sc_hd__nor2_1
X_1569_ net26 _0964_ _0966_ net23 VGND VGND VPWR VPWR _0970_ sky130_fd_sc_hd__o22a_1
XFILLER_14_217 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_22_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_49_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_49_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_9_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_15_223 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_20_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkload13 clknet_4_14_0_sys_clk VGND VGND VPWR VPWR clkload13/Y sky130_fd_sc_hd__bufinv_16
X_1285_ _0686_ _0687_ VGND VGND VPWR VPWR _0688_ sky130_fd_sc_hd__nand2_1
XFILLER_48_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1354_ _0752_ _0753_ _0754_ _0718_ VGND VGND VPWR VPWR _0755_ sky130_fd_sc_hd__a31o_1
X_1423_ net280 _0702_ VGND VGND VPWR VPWR _0824_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_38_359 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_34_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_50_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkload7 clknet_4_8_0_sys_clk VGND VGND VPWR VPWR clkload7/Y sky130_fd_sc_hd__clkinv_4
XTAP_TAPCELL_ROW_21_259 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout222 net224 VGND VGND VPWR VPWR net222 sky130_fd_sc_hd__clkbuf_1
Xfanout200 net208 VGND VGND VPWR VPWR net200 sky130_fd_sc_hd__clkbuf_2
Xfanout211 net214 VGND VGND VPWR VPWR net211 sky130_fd_sc_hd__buf_6
Xfanout299 net300 VGND VGND VPWR VPWR net299 sky130_fd_sc_hd__dlymetal6s2s_1
Xfanout244 net245 VGND VGND VPWR VPWR net244 sky130_fd_sc_hd__buf_1
Xfanout266 net267 VGND VGND VPWR VPWR net266 sky130_fd_sc_hd__buf_1
XFILLER_46_128 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_39_191 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout277 net278 VGND VGND VPWR VPWR net277 sky130_fd_sc_hd__buf_1
XTAP_TAPCELL_ROW_29_304 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout288 net290 VGND VGND VPWR VPWR net288 sky130_fd_sc_hd__buf_1
Xfanout255 net257 VGND VGND VPWR VPWR net255 sky130_fd_sc_hd__dlymetal6s2s_1
Xfanout233 lf_inst.integrator\[0\] VGND VGND VPWR VPWR net233 sky130_fd_sc_hd__buf_1
XFILLER_19_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_54_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_54_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_42_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_42_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_24_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_24_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_12_204 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_6_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_10_220 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1070_ net326 net233 net284 VGND VGND VPWR VPWR _0503_ sky130_fd_sc_hd__o21ai_1
XFILLER_60_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_60_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1972_ _0193_ _0194_ net160 VGND VGND VPWR VPWR _0406_ sky130_fd_sc_hd__and3_1
XPHY_EDGE_ROW_49_Right_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_58_Right_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1268_ _0671_ _0672_ VGND VGND VPWR VPWR _0673_ sky130_fd_sc_hd__nand2_1
X_1337_ div_inst.counter\[2\] _0736_ VGND VGND VPWR VPWR _0738_ sky130_fd_sc_hd__and2_1
Xhold19 lf_inst.integrator\[3\] VGND VGND VPWR VPWR net329 sky130_fd_sc_hd__dlygate4sd3_1
X_1406_ _0766_ _0806_ VGND VGND VPWR VPWR _0807_ sky130_fd_sc_hd__and2_1
XFILLER_43_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1199_ dco_inst.accumulator\[19\] net77 VGND VGND VPWR VPWR _0613_ sky130_fd_sc_hd__and2_1
XFILLER_59_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_59_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_3_249 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_42_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_42_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_35_84 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_30_326 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_30_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_48_421 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2171_ clknet_4_10_0_sys_clk _0071_ VGND VGND VPWR VPWR lf_inst.integrator\[21\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_32_6 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1122_ dco_inst.accumulator\[9\] net98 VGND VGND VPWR VPWR _0546_ sky130_fd_sc_hd__nor2_1
X_2240_ net239 _0139_ VGND VGND VPWR VPWR div_inst.counter\[19\] sky130_fd_sc_hd__dfxtp_1
X_1053_ net337 VGND VGND VPWR VPWR _0491_ sky130_fd_sc_hd__inv_2
XFILLER_21_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1955_ net345 _1018_ _0174_ _0391_ VGND VGND VPWR VPWR _0104_ sky130_fd_sc_hd__o22a_1
X_1886_ net251 net61 net330 net173 _0332_ VGND VGND VPWR VPWR _0094_ sky130_fd_sc_hd__a221o_1
XFILLER_56_289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_54_457 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_21_42 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_21_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_47_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_47_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_45_402 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1740_ net264 net46 VGND VGND VPWR VPWR _0210_ sky130_fd_sc_hd__and2_1
XFILLER_30_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_30_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_30_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_7_22 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1671_ net253 net37 VGND VGND VPWR VPWR _1046_ sky130_fd_sc_hd__and2_1
XFILLER_7_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2223_ net245 _0122_ VGND VGND VPWR VPWR div_inst.counter\[2\] sky130_fd_sc_hd__dfxtp_1
XFILLER_53_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_38_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2154_ clknet_4_7_0_sys_clk _0001_ VGND VGND VPWR VPWR pfd_inst.state\[1\] sky130_fd_sc_hd__dfxtp_1
X_1105_ dco_inst.accumulator\[5\] net94 _0521_ _0522_ _0520_ VGND VGND VPWR VPWR _0532_
+ sky130_fd_sc_hd__a221o_1
X_2085_ net260 _0904_ net106 net118 VGND VGND VPWR VPWR _0139_ sky130_fd_sc_hd__and4bb_1
XTAP_TAPCELL_ROW_51_438 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_21_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1869_ _0316_ _0317_ VGND VGND VPWR VPWR _0318_ sky130_fd_sc_hd__nand2_1
X_1938_ _0368_ _0371_ _0376_ VGND VGND VPWR VPWR _0377_ sky130_fd_sc_hd__a21bo_1
XPHY_EDGE_ROW_48_Left_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_16_64 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_57_Left_118 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_32_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_4_333 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_35_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_7_171 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_50_218 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_43_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1723_ _0193_ _0194_ VGND VGND VPWR VPWR _0195_ sky130_fd_sc_hd__nand2_1
X_1654_ _1029_ _1030_ VGND VGND VPWR VPWR _1031_ sky130_fd_sc_hd__or2_1
XFILLER_58_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2206_ clknet_4_9_0_sys_clk _0105_ VGND VGND VPWR VPWR net75 sky130_fd_sc_hd__dfxtp_1
X_1585_ _0886_ _0985_ _0888_ _0901_ VGND VGND VPWR VPWR _0986_ sky130_fd_sc_hd__or4b_1
X_2068_ net274 _0964_ net110 net122 VGND VGND VPWR VPWR _0122_ sky130_fd_sc_hd__and4bb_1
X_2137_ clknet_4_1_0_sys_clk _0040_ VGND VGND VPWR VPWR lf_inst.integrator\[4\] sky130_fd_sc_hd__dfxtp_1
XFILLER_5_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_4_152 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_40_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_25_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_25_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_4_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_4_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1370_ _0770_ VGND VGND VPWR VPWR _0771_ sky130_fd_sc_hd__inv_2
XFILLER_48_351 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1706_ net361 net180 _0178_ _0179_ VGND VGND VPWR VPWR _0067_ sky130_fd_sc_hd__a211o_1
X_1637_ _1013_ net191 VGND VGND VPWR VPWR _1016_ sky130_fd_sc_hd__nor2_1
XFILLER_48_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1568_ net306 _0961_ _0965_ _0968_ _0959_ VGND VGND VPWR VPWR _0969_ sky130_fd_sc_hd__o221a_1
X_1499_ net14 _0896_ _0895_ VGND VGND VPWR VPWR _0900_ sky130_fd_sc_hd__o21a_1
XFILLER_54_354 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_54_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_14_229 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_13_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_54_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_9_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkload14 clknet_4_15_0_sys_clk VGND VGND VPWR VPWR clkload14/X sky130_fd_sc_hd__clkbuf_8
X_1422_ div_inst.counter\[19\] _0814_ _0818_ net140 VGND VGND VPWR VPWR _0823_ sky130_fd_sc_hd__o22a_1
X_1284_ _0672_ _0678_ _0680_ _0679_ VGND VGND VPWR VPWR _0687_ sky130_fd_sc_hd__a31o_1
XFILLER_55_118 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1353_ div_inst.counter\[9\] _0720_ VGND VGND VPWR VPWR _0754_ sky130_fd_sc_hd__nand2_1
XFILLER_51_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkload8 clknet_4_9_0_sys_clk VGND VGND VPWR VPWR clkload8/Y sky130_fd_sc_hd__clkinvlp_4
Xfanout245 net246 VGND VGND VPWR VPWR net245 sky130_fd_sc_hd__dlymetal6s2s_1
Xfanout223 net224 VGND VGND VPWR VPWR net223 sky130_fd_sc_hd__clkbuf_1
Xfanout212 net214 VGND VGND VPWR VPWR net212 sky130_fd_sc_hd__clkbuf_2
Xfanout201 net202 VGND VGND VPWR VPWR net201 sky130_fd_sc_hd__clkbuf_1
Xfanout234 lf_inst.integrator\[0\] VGND VGND VPWR VPWR net234 sky130_fd_sc_hd__clkbuf_1
Xfanout256 net257 VGND VGND VPWR VPWR net256 sky130_fd_sc_hd__buf_1
Xfanout267 net268 VGND VGND VPWR VPWR net267 sky130_fd_sc_hd__dlymetal6s2s_1
Xfanout278 net279 VGND VGND VPWR VPWR net278 sky130_fd_sc_hd__buf_1
Xfanout289 net290 VGND VGND VPWR VPWR net289 sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_29_305 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_27_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_54_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_42_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_24_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_10_232 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_12_205 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_40_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_10_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_60_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_1_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_60_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1971_ net360 net179 _0404_ _0405_ _0189_ VGND VGND VPWR VPWR _0106_ sky130_fd_sc_hd__a221o_1
X_1405_ _0494_ _0765_ net14 VGND VGND VPWR VPWR _0806_ sky130_fd_sc_hd__a21bo_1
X_1267_ dco_inst.accumulator\[28\] net87 VGND VGND VPWR VPWR _0672_ sky130_fd_sc_hd__nand2_1
X_1336_ div_inst.counter\[2\] _0736_ VGND VGND VPWR VPWR _0737_ sky130_fd_sc_hd__nor2_1
Xinput1 div_val[0] VGND VGND VPWR VPWR net1 sky130_fd_sc_hd__clkbuf_1
X_1198_ dco_inst.accumulator\[19\] net77 VGND VGND VPWR VPWR _0612_ sky130_fd_sc_hd__nor2_1
XFILLER_59_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_15_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_30_338 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_27_Left_88 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_2_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2170_ clknet_4_10_0_sys_clk _0070_ VGND VGND VPWR VPWR lf_inst.integrator\[20\]
+ sky130_fd_sc_hd__dfxtp_1
X_1052_ net286 VGND VGND VPWR VPWR _0490_ sky130_fd_sc_hd__inv_2
X_1121_ _0545_ _0544_ VGND VGND VPWR VPWR _0012_ sky130_fd_sc_hd__and2b_1
XFILLER_33_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1954_ net252 _0390_ VGND VGND VPWR VPWR _0391_ sky130_fd_sc_hd__nor2_1
XFILLER_21_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1885_ _0330_ _0331_ VGND VGND VPWR VPWR _0332_ sky130_fd_sc_hd__nor2_1
XFILLER_56_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1319_ _0698_ _0719_ VGND VGND VPWR VPWR _0720_ sky130_fd_sc_hd__and2_1
XFILLER_8_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_12_316 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_21_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_21_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_47_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_45_403 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_15_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_15_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1670_ _1044_ VGND VGND VPWR VPWR _1045_ sky130_fd_sc_hd__inv_2
XFILLER_7_34 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_7_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2222_ net245 _0121_ VGND VGND VPWR VPWR div_inst.counter\[1\] sky130_fd_sc_hd__dfxtp_1
XFILLER_23_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2153_ clknet_4_7_0_sys_clk _0000_ VGND VGND VPWR VPWR pfd_inst.state\[0\] sky130_fd_sc_hd__dfxtp_1
X_2084_ net259 _0908_ net105 net117 VGND VGND VPWR VPWR _0138_ sky130_fd_sc_hd__and4bb_1
X_1104_ _0529_ _0530_ VGND VGND VPWR VPWR _0531_ sky130_fd_sc_hd__and2b_1
XTAP_TAPCELL_ROW_51_439 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_21_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1937_ _1039_ net165 _0370_ _1044_ VGND VGND VPWR VPWR _0376_ sky130_fd_sc_hd__o2bb2a_1
X_1799_ _0259_ _0261_ VGND VGND VPWR VPWR _0262_ sky130_fd_sc_hd__nand2_1
X_1868_ lf_inst.integrator\[4\] net164 VGND VGND VPWR VPWR _0317_ sky130_fd_sc_hd__nand2_1
XFILLER_29_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_29_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_16_10 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_4_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_4_345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_7_172 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_35_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_43_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1584_ _0947_ _0972_ _0984_ _0980_ VGND VGND VPWR VPWR _0985_ sky130_fd_sc_hd__or4b_1
X_1722_ _0181_ _0185_ _0192_ VGND VGND VPWR VPWR _0194_ sky130_fd_sc_hd__a21o_1
XPHY_EDGE_ROW_9_Right_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_11_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1653_ lf_inst.integrator\[11\] net168 VGND VGND VPWR VPWR _1030_ sky130_fd_sc_hd__and2_1
X_2205_ clknet_4_9_0_sys_clk _0104_ VGND VGND VPWR VPWR net74 sky130_fd_sc_hd__dfxtp_1
X_2067_ net275 _0966_ net110 net122 VGND VGND VPWR VPWR _0121_ sky130_fd_sc_hd__and4bb_1
XFILLER_26_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2136_ clknet_4_1_0_sys_clk _0039_ VGND VGND VPWR VPWR lf_inst.integrator\[3\] sky130_fd_sc_hd__dfxtp_1
XPHY_EDGE_ROW_14_Left_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_1_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_4_153 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_25_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_10_188 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_4_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1705_ net263 net41 VGND VGND VPWR VPWR _0179_ sky130_fd_sc_hd__and2_1
XFILLER_31_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_31_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1567_ net26 _0964_ _0967_ VGND VGND VPWR VPWR _0968_ sky130_fd_sc_hd__o21ba_1
X_1636_ net296 net229 VGND VGND VPWR VPWR _1015_ sky130_fd_sc_hd__nand2_1
XFILLER_58_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_54_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_39_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2119_ clknet_4_8_0_sys_clk _0022_ VGND VGND VPWR VPWR dco_inst.accumulator\[18\]
+ sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_1_134 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1498_ _0893_ _0898_ _0890_ VGND VGND VPWR VPWR _0899_ sky130_fd_sc_hd__a21bo_1
XFILLER_49_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_1_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1421_ _0816_ _0820_ VGND VGND VPWR VPWR _0822_ sky130_fd_sc_hd__and2_1
X_1283_ _0684_ _0685_ VGND VGND VPWR VPWR _0686_ sky130_fd_sc_hd__nand2_1
XFILLER_48_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1352_ div_inst.counter\[10\] _0716_ VGND VGND VPWR VPWR _0753_ sky130_fd_sc_hd__nand2_1
Xclkload9 clknet_4_10_0_sys_clk VGND VGND VPWR VPWR clkload9/X sky130_fd_sc_hd__clkbuf_8
XFILLER_59_18 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout246 net100 VGND VGND VPWR VPWR net246 sky130_fd_sc_hd__buf_1
Xfanout224 net225 VGND VGND VPWR VPWR net224 sky130_fd_sc_hd__clkbuf_1
Xfanout268 net278 VGND VGND VPWR VPWR net268 sky130_fd_sc_hd__buf_1
Xfanout213 net214 VGND VGND VPWR VPWR net213 sky130_fd_sc_hd__buf_1
Xfanout235 net240 VGND VGND VPWR VPWR net235 sky130_fd_sc_hd__buf_1
Xfanout202 net208 VGND VGND VPWR VPWR net202 sky130_fd_sc_hd__clkbuf_2
Xfanout257 net261 VGND VGND VPWR VPWR net257 sky130_fd_sc_hd__buf_1
Xfanout279 _0490_ VGND VGND VPWR VPWR net279 sky130_fd_sc_hd__buf_1
X_1619_ _1004_ net209 _1003_ VGND VGND VPWR VPWR _0052_ sky130_fd_sc_hd__and3b_1
XFILLER_54_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_39_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_37_350 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_29_306 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_27_322 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_10_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_20_250 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_10_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_60_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1970_ _0401_ _0402_ _0403_ net194 VGND VGND VPWR VPWR _0405_ sky130_fd_sc_hd__a31oi_1
XFILLER_53_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_43_386 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1335_ net23 _0693_ VGND VGND VPWR VPWR _0736_ sky130_fd_sc_hd__xnor2_1
XFILLER_5_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1404_ _0767_ _0804_ VGND VGND VPWR VPWR _0805_ sky130_fd_sc_hd__and2b_1
X_1266_ dco_inst.accumulator\[28\] net87 VGND VGND VPWR VPWR _0671_ sky130_fd_sc_hd__or2_1
Xinput2 div_val[10] VGND VGND VPWR VPWR net2 sky130_fd_sc_hd__clkbuf_1
X_1197_ net294 _0610_ _0611_ VGND VGND VPWR VPWR _0022_ sky130_fd_sc_hd__and3_1
XFILLER_24_314 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_10_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_10_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_59_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_10_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_42_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_15_314 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_2_Left_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_25_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1120_ _0535_ _0539_ _0543_ net255 VGND VGND VPWR VPWR _0545_ sky130_fd_sc_hd__a31o_1
X_1051_ unlock_timer\[5\] VGND VGND VPWR VPWR _0489_ sky130_fd_sc_hd__inv_2
X_1953_ _0385_ _0389_ VGND VGND VPWR VPWR _0390_ sky130_fd_sc_hd__xnor2_1
X_1884_ _0327_ _0328_ _0329_ net192 VGND VGND VPWR VPWR _0331_ sky130_fd_sc_hd__a31o_1
XFILLER_21_306 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1318_ net304 net31 _0696_ net32 VGND VGND VPWR VPWR _0719_ sky130_fd_sc_hd__o31ai_1
X_1249_ _0645_ _0652_ _0655_ net266 VGND VGND VPWR VPWR _0657_ sky130_fd_sc_hd__a31o_1
XFILLER_24_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_12_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_47_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_47_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_46_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_30_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_7_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2221_ net243 _0120_ VGND VGND VPWR VPWR div_inst.counter\[0\] sky130_fd_sc_hd__dfxtp_1
X_2152_ clknet_4_2_0_sys_clk _0055_ VGND VGND VPWR VPWR unlock_timer\[5\] sky130_fd_sc_hd__dfxtp_1
X_2083_ net259 _0912_ net104 net116 VGND VGND VPWR VPWR _0137_ sky130_fd_sc_hd__and4bb_1
X_1103_ dco_inst.accumulator\[6\] net95 VGND VGND VPWR VPWR _0530_ sky130_fd_sc_hd__or2_1
X_1867_ lf_inst.integrator\[4\] net164 VGND VGND VPWR VPWR _0316_ sky130_fd_sc_hd__or2_1
XFILLER_21_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1936_ net169 _0156_ VGND VGND VPWR VPWR _0375_ sky130_fd_sc_hd__xnor2_1
X_1798_ _0260_ VGND VGND VPWR VPWR _0261_ sky130_fd_sc_hd__inv_2
Xinput60 initial_freq[5] VGND VGND VPWR VPWR net60 sky130_fd_sc_hd__clkbuf_1
XFILLER_44_228 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_52_294 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_52_261 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_16_88 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_4_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_8_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_20_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_57_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_7_173 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_50_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_28_291 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1721_ _0181_ _0185_ _0192_ VGND VGND VPWR VPWR _0193_ sky130_fd_sc_hd__nand3_1
X_1583_ net151 net311 VGND VGND VPWR VPWR _0984_ sky130_fd_sc_hd__and2_1
XFILLER_7_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1652_ lf_inst.integrator\[11\] net168 VGND VGND VPWR VPWR _1029_ sky130_fd_sc_hd__nor2_1
XFILLER_58_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2204_ clknet_4_2_0_sys_clk _0103_ VGND VGND VPWR VPWR net73 sky130_fd_sc_hd__dfxtp_1
X_2135_ clknet_4_0_0_sys_clk _0038_ VGND VGND VPWR VPWR lf_inst.integrator\[2\] sky130_fd_sc_hd__dfxtp_1
X_2066_ net152 net121 net109 net299 VGND VGND VPWR VPWR _0120_ sky130_fd_sc_hd__and4b_1
X_1919_ _0351_ _0355_ _0359_ VGND VGND VPWR VPWR _0361_ sky130_fd_sc_hd__o21ai_1
XFILLER_1_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_1_305 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_32_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_4_154 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_40_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_40_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_10_189 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_48_320 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_31_Left_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1704_ net193 _0177_ VGND VGND VPWR VPWR _0178_ sky130_fd_sc_hd__nor2_1
XFILLER_31_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1566_ net23 _0966_ VGND VGND VPWR VPWR _0967_ sky130_fd_sc_hd__nand2_1
X_1635_ net296 net229 VGND VGND VPWR VPWR _1014_ sky130_fd_sc_hd__and2_1
X_1497_ _0895_ _0897_ VGND VGND VPWR VPWR _0898_ sky130_fd_sc_hd__nand2_1
X_2049_ _0271_ _0472_ VGND VGND VPWR VPWR _0473_ sky130_fd_sc_hd__nand2_1
X_2118_ clknet_4_9_0_sys_clk _0021_ VGND VGND VPWR VPWR dco_inst.accumulator\[17\]
+ sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_1_135 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_38_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_60_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_57_183 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_57_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_9_202 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_23_270 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1351_ _0749_ _0750_ _0751_ _0722_ VGND VGND VPWR VPWR _0752_ sky130_fd_sc_hd__a31o_1
X_1420_ _0820_ VGND VGND VPWR VPWR _0821_ sky130_fd_sc_hd__inv_2
X_1282_ dco_inst.accumulator\[30\] net90 VGND VGND VPWR VPWR _0685_ sky130_fd_sc_hd__or2_1
XFILLER_36_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_51_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1618_ unlock_timer\[2\] unlock_timer\[1\] _1000_ VGND VGND VPWR VPWR _1004_ sky130_fd_sc_hd__and3_1
X_1549_ net303 _0948_ _0949_ net304 VGND VGND VPWR VPWR _0950_ sky130_fd_sc_hd__a22o_1
Xfanout225 net226 VGND VGND VPWR VPWR net225 sky130_fd_sc_hd__buf_1
Xfanout203 net207 VGND VGND VPWR VPWR net203 sky130_fd_sc_hd__clkbuf_2
Xfanout269 net271 VGND VGND VPWR VPWR net269 sky130_fd_sc_hd__buf_1
XTAP_TAPCELL_ROW_29_307 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout236 net237 VGND VGND VPWR VPWR net236 sky130_fd_sc_hd__clkbuf_1
Xfanout247 dynamic_ki\[2\] VGND VGND VPWR VPWR net247 sky130_fd_sc_hd__buf_1
Xfanout214 net215 VGND VGND VPWR VPWR net214 sky130_fd_sc_hd__buf_6
Xfanout258 net259 VGND VGND VPWR VPWR net258 sky130_fd_sc_hd__buf_1
XFILLER_54_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_42_326 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_42_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_37_351 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_27_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_6_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_20_251 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_49_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_1_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_18_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_60_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_45_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_45_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_43_387 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_33_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_33_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_33_304 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1265_ net299 _0669_ _0670_ VGND VGND VPWR VPWR _0031_ sky130_fd_sc_hd__and3_1
X_1334_ _0694_ _0730_ div_inst.counter\[3\] VGND VGND VPWR VPWR _0735_ sky130_fd_sc_hd__a21oi_1
XFILLER_5_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1403_ net310 net129 VGND VGND VPWR VPWR _0804_ sky130_fd_sc_hd__nand2_1
XPHY_EDGE_ROW_18_Right_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_51_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_51_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xinput3 div_val[11] VGND VGND VPWR VPWR net3 sky130_fd_sc_hd__dlymetal6s2s_1
X_1196_ _0608_ _0609_ _0604_ _0605_ VGND VGND VPWR VPWR _0611_ sky130_fd_sc_hd__a211o_1
XTAP_TAPCELL_ROW_34_332 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_27_Right_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_24_326 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_36_Right_36 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_3_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_10_13 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_45_Right_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_35_32 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_30_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_54_Right_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_40_368 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1050_ lf_inst.zero_error_count\[3\] VGND VGND VPWR VPWR _0488_ sky130_fd_sc_hd__inv_2
XFILLER_33_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_18_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_18_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1952_ _0386_ _0387_ _0388_ VGND VGND VPWR VPWR _0389_ sky130_fd_sc_hd__and3_1
X_1883_ _0328_ _0329_ _0327_ VGND VGND VPWR VPWR _0330_ sky130_fd_sc_hd__a21oi_1
XFILLER_21_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1248_ _0645_ _0652_ _0655_ VGND VGND VPWR VPWR _0656_ sky130_fd_sc_hd__a21oi_1
X_1317_ div_inst.counter\[10\] _0716_ _0717_ div_inst.counter\[11\] VGND VGND VPWR
+ VPWR _0718_ sky130_fd_sc_hd__o22ai_1
X_1179_ _0581_ _0594_ _0595_ VGND VGND VPWR VPWR _0596_ sky130_fd_sc_hd__o21ai_1
XFILLER_12_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_20_351 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_21_78 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_55_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_47_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_15_123 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_30_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_11_351 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2220_ clknet_4_15_0_sys_clk _0119_ VGND VGND VPWR VPWR net91 sky130_fd_sc_hd__dfxtp_1
XFILLER_30_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2082_ net259 _0914_ net103 net115 VGND VGND VPWR VPWR _0136_ sky130_fd_sc_hd__and4bb_1
X_1102_ dco_inst.accumulator\[6\] net95 VGND VGND VPWR VPWR _0529_ sky130_fd_sc_hd__and2_1
X_2151_ clknet_4_3_0_sys_clk _0054_ VGND VGND VPWR VPWR unlock_timer\[4\] sky130_fd_sc_hd__dfxtp_1
Xinput50 initial_freq[25] VGND VGND VPWR VPWR net50 sky130_fd_sc_hd__clkbuf_1
X_1797_ lf_inst.integrator\[24\] lf_inst.integrator\[25\] lf_inst.integrator\[26\]
+ lf_inst.integrator\[27\] net221 VGND VGND VPWR VPWR _0260_ sky130_fd_sc_hd__o41a_1
X_1866_ net343 net171 _0315_ net202 _0997_ VGND VGND VPWR VPWR _0091_ sky130_fd_sc_hd__a221o_1
Xinput61 initial_freq[6] VGND VGND VPWR VPWR net61 sky130_fd_sc_hd__clkbuf_1
X_1935_ net168 _0156_ VGND VGND VPWR VPWR _0374_ sky130_fd_sc_hd__nand2_1
XFILLER_37_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_52_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_50_430 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_0_Right_0 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_16_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_7_174 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_44_Left_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1720_ _0190_ _0191_ VGND VGND VPWR VPWR _0192_ sky130_fd_sc_hd__nand2_2
X_1651_ _1011_ _1023_ _1022_ VGND VGND VPWR VPWR _1028_ sky130_fd_sc_hd__a21oi_1
X_1582_ _0899_ _0982_ _0888_ VGND VGND VPWR VPWR _0983_ sky130_fd_sc_hd__a21o_1
XPHY_EDGE_ROW_53_Left_114 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2065_ net205 _0485_ _0484_ _0486_ VGND VGND VPWR VPWR _0119_ sky130_fd_sc_hd__a31o_1
X_2134_ clknet_4_3_0_sys_clk _0037_ VGND VGND VPWR VPWR lf_inst.integrator\[1\] sky130_fd_sc_hd__dfxtp_1
X_2203_ clknet_4_2_0_sys_clk _0102_ VGND VGND VPWR VPWR net72 sky130_fd_sc_hd__dfxtp_1
XFILLER_34_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1849_ net231 _1010_ net283 VGND VGND VPWR VPWR _0301_ sky130_fd_sc_hd__and3b_1
X_1918_ _0351_ _0355_ _0359_ VGND VGND VPWR VPWR _0360_ sky130_fd_sc_hd__or3_1
XTAP_TAPCELL_ROW_4_155 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_1_317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_43_10 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_25_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_17_207 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_40_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1703_ _0175_ _0176_ VGND VGND VPWR VPWR _0177_ sky130_fd_sc_hd__xor2_2
X_1634_ _1011_ _1012_ VGND VGND VPWR VPWR _1013_ sky130_fd_sc_hd__or2_1
X_1565_ net150 net148 VGND VGND VPWR VPWR _0966_ sky130_fd_sc_hd__xnor2_1
X_1496_ net15 _0894_ _0896_ net14 VGND VGND VPWR VPWR _0897_ sky130_fd_sc_hd__a22o_1
X_2048_ net228 net248 net232 net160 VGND VGND VPWR VPWR _0472_ sky130_fd_sc_hd__a31o_1
X_2117_ clknet_4_2_0_sys_clk _0020_ VGND VGND VPWR VPWR dco_inst.accumulator\[16\]
+ sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_1_136 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_22_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_57_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_45_324 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_1_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_60_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_60_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_9_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_13_210 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_23_271 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_9_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_13_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1281_ dco_inst.accumulator\[30\] net90 VGND VGND VPWR VPWR _0684_ sky130_fd_sc_hd__nand2_1
X_1350_ div_inst.counter\[8\] _0721_ VGND VGND VPWR VPWR _0751_ sky130_fd_sc_hd__nand2_1
XFILLER_51_305 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_51_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xfanout204 net206 VGND VGND VPWR VPWR net204 sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_8_291 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1617_ _0489_ unlock_timer\[1\] unlock_timer\[0\] unlock_timer\[2\] VGND VGND VPWR
+ VPWR _1003_ sky130_fd_sc_hd__a31o_1
X_1548_ div_inst.counter\[6\] _0849_ VGND VGND VPWR VPWR _0949_ sky130_fd_sc_hd__xnor2_1
Xfanout226 net227 VGND VGND VPWR VPWR net226 sky130_fd_sc_hd__clkbuf_1
Xfanout248 dynamic_ki\[2\] VGND VGND VPWR VPWR net248 sky130_fd_sc_hd__buf_1
Xfanout237 net240 VGND VGND VPWR VPWR net237 sky130_fd_sc_hd__dlymetal6s2s_1
Xfanout215 lf_inst.error_in\[1\] VGND VGND VPWR VPWR net215 sky130_fd_sc_hd__buf_6
X_1479_ _0866_ _0879_ VGND VGND VPWR VPWR _0880_ sky130_fd_sc_hd__or2_1
Xfanout259 net261 VGND VGND VPWR VPWR net259 sky130_fd_sc_hd__clkbuf_2
XFILLER_54_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_37_352 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_10_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_10_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_20_252 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_40_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_6_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_60_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_45_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_33_316 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_1_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_18_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_60_146 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_43_388 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_5_261 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1402_ div_inst.counter\[23\] _0802_ VGND VGND VPWR VPWR _0803_ sky130_fd_sc_hd__nand2_1
X_1264_ _0659_ _0664_ _0666_ _0667_ VGND VGND VPWR VPWR _0670_ sky130_fd_sc_hd__a211o_1
X_1333_ net146 _0733_ VGND VGND VPWR VPWR _0734_ sky130_fd_sc_hd__nand2_1
XFILLER_39_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xinput4 div_val[12] VGND VGND VPWR VPWR net4 sky130_fd_sc_hd__buf_1
Xclkbuf_4_2_0_sys_clk clknet_0_sys_clk VGND VGND VPWR VPWR clknet_4_2_0_sys_clk sky130_fd_sc_hd__clkbuf_8
X_1195_ _0604_ _0605_ _0608_ _0609_ VGND VGND VPWR VPWR _0610_ sky130_fd_sc_hd__o211ai_1
XTAP_TAPCELL_ROW_34_333 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_24_338 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_35_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_51_21 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_42_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_51_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_40_369 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_2_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_18_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_31_314 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1882_ _0321_ _0323_ VGND VGND VPWR VPWR _0329_ sky130_fd_sc_hd__or2_1
X_1951_ net166 _0161_ net128 _0374_ VGND VGND VPWR VPWR _0388_ sky130_fd_sc_hd__o211a_1
X_1247_ _0653_ _0654_ VGND VGND VPWR VPWR _0655_ sky130_fd_sc_hd__nand2_1
X_1316_ net3 _0699_ VGND VGND VPWR VPWR _0717_ sky130_fd_sc_hd__xnor2_1
X_1178_ _0577_ _0587_ _0586_ VGND VGND VPWR VPWR _0595_ sky130_fd_sc_hd__o21ba_1
XFILLER_24_179 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_24_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_21_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_55_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_55_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_53_450 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_47_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_46_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_15_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_15_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2081_ net269 _0920_ net108 net120 VGND VGND VPWR VPWR _0135_ sky130_fd_sc_hd__and4bb_1
X_1101_ net282 _0527_ _0528_ VGND VGND VPWR VPWR _0009_ sky130_fd_sc_hd__and3_1
X_2150_ clknet_4_3_0_sys_clk _0053_ VGND VGND VPWR VPWR unlock_timer\[3\] sky130_fd_sc_hd__dfxtp_1
XFILLER_46_282 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1934_ net71 net174 _0373_ net200 _1046_ VGND VGND VPWR VPWR _0101_ sky130_fd_sc_hd__a221o_1
Xinput51 initial_freq[26] VGND VGND VPWR VPWR net51 sky130_fd_sc_hd__clkbuf_1
X_1796_ _0231_ _0238_ _0247_ _0252_ VGND VGND VPWR VPWR _0259_ sky130_fd_sc_hd__or4_4
Xinput40 initial_freq[16] VGND VGND VPWR VPWR net40 sky130_fd_sc_hd__clkbuf_1
Xinput62 initial_freq[7] VGND VGND VPWR VPWR net62 sky130_fd_sc_hd__clkbuf_1
X_1865_ _0312_ _0314_ VGND VGND VPWR VPWR _0315_ sky130_fd_sc_hd__xnor2_1
XFILLER_37_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_50_431 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_57_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_7_175 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_28_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1650_ net315 net171 _1026_ _1027_ VGND VGND VPWR VPWR _0060_ sky130_fd_sc_hd__a211o_1
X_1581_ _0918_ _0981_ _0901_ VGND VGND VPWR VPWR _0982_ sky130_fd_sc_hd__o21ai_1
X_2202_ clknet_4_6_0_sys_clk _0101_ VGND VGND VPWR VPWR net71 sky130_fd_sc_hd__dfxtp_1
XFILLER_21_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2064_ net91 net185 _0283_ VGND VGND VPWR VPWR _0486_ sky130_fd_sc_hd__a21o_1
X_2133_ net235 _0036_ VGND VGND VPWR VPWR div_inst.clk_out sky130_fd_sc_hd__dfxtp_1
XFILLER_34_274 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1917_ _0357_ _0358_ VGND VGND VPWR VPWR _0359_ sky130_fd_sc_hd__nor2_1
X_1779_ net221 lf_inst.integrator\[26\] VGND VGND VPWR VPWR _0244_ sky130_fd_sc_hd__or2_1
X_1848_ _0299_ _0300_ VGND VGND VPWR VPWR _0088_ sky130_fd_sc_hd__and2_1
XFILLER_1_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_4_156 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_17_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_40_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_48_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_4_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_4_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_18_236 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_31_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_31_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_31_200 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1564_ net306 _0961_ _0964_ net26 VGND VGND VPWR VPWR _0965_ sky130_fd_sc_hd__a22o_1
X_1702_ net213 lf_inst.integrator\[16\] _0168_ _0170_ VGND VGND VPWR VPWR _0176_ sky130_fd_sc_hd__a22o_1
X_1633_ lf_inst.integrator\[9\] _1010_ VGND VGND VPWR VPWR _1012_ sky130_fd_sc_hd__nor2_1
XPHY_EDGE_ROW_18_Left_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1495_ div_inst.counter\[20\] _0861_ VGND VGND VPWR VPWR _0896_ sky130_fd_sc_hd__xor2_1
X_2047_ net204 _0469_ _0470_ _0471_ VGND VGND VPWR VPWR _0116_ sky130_fd_sc_hd__a31o_1
X_2116_ clknet_4_2_0_sys_clk _0019_ VGND VGND VPWR VPWR dco_inst.accumulator\[15\]
+ sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_1_137 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_57_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_9_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_13_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_13_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1280_ _0682_ _0683_ VGND VGND VPWR VPWR _0033_ sky130_fd_sc_hd__nor2_1
XFILLER_48_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_51_317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_48_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_36_325 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1547_ net145 net134 VGND VGND VPWR VPWR _0948_ sky130_fd_sc_hd__xnor2_1
Xfanout205 net206 VGND VGND VPWR VPWR net205 sky130_fd_sc_hd__buf_1
Xfanout216 net220 VGND VGND VPWR VPWR net216 sky130_fd_sc_hd__buf_1
X_1616_ net358 _1000_ _1002_ VGND VGND VPWR VPWR _0051_ sky130_fd_sc_hd__o21a_1
Xfanout238 net239 VGND VGND VPWR VPWR net238 sky130_fd_sc_hd__buf_1
XFILLER_54_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout249 _0694_ VGND VGND VPWR VPWR net249 sky130_fd_sc_hd__buf_1
XFILLER_39_152 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1478_ div_inst.counter\[26\] _0865_ VGND VGND VPWR VPWR _0879_ sky130_fd_sc_hd__nor2_1
XFILLER_42_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_37_353 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_10_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_20_253 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_49_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_49_10 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_1_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_60_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_43_389 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_41_350 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_5_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1401_ net16 _0767_ VGND VGND VPWR VPWR _0802_ sky130_fd_sc_hd__xnor2_1
X_1263_ _0666_ _0667_ _0659_ _0664_ VGND VGND VPWR VPWR _0669_ sky130_fd_sc_hd__o211ai_1
X_1332_ _0695_ _0732_ VGND VGND VPWR VPWR _0733_ sky130_fd_sc_hd__nor2_1
Xinput5 div_val[13] VGND VGND VPWR VPWR net5 sky130_fd_sc_hd__clkbuf_1
X_1194_ _0591_ _0600_ _0599_ VGND VGND VPWR VPWR _0609_ sky130_fd_sc_hd__a21bo_1
Xclkbuf_4_6_0_sys_clk clknet_0_sys_clk VGND VGND VPWR VPWR clknet_4_6_0_sys_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_36_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_34_334 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_10_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_51_33 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_35_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_30_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_2_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_18_111 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_33_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_31_315 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1950_ _0165_ _0364_ VGND VGND VPWR VPWR _0387_ sky130_fd_sc_hd__or2_1
X_1881_ lf_inst.integrator\[4\] lf_inst.integrator\[5\] net162 VGND VGND VPWR VPWR
+ _0328_ sky130_fd_sc_hd__o21ai_1
X_1315_ _0699_ _0715_ VGND VGND VPWR VPWR _0716_ sky130_fd_sc_hd__nor2_1
X_1246_ dco_inst.accumulator\[25\] net84 VGND VGND VPWR VPWR _0654_ sky130_fd_sc_hd__nand2_1
XFILLER_56_239 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1177_ _0583_ _0593_ VGND VGND VPWR VPWR _0594_ sky130_fd_sc_hd__nand2_1
XFILLER_24_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_12_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_6_Left_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_53_451 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_46_88 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_15_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_15_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_7_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_11_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2080_ net269 _0922_ net104 net116 VGND VGND VPWR VPWR _0134_ sky130_fd_sc_hd__and4bb_1
X_1100_ _0525_ _0526_ _0520_ _0524_ VGND VGND VPWR VPWR _0528_ sky130_fd_sc_hd__a211o_1
X_1933_ _0371_ _0372_ VGND VGND VPWR VPWR _0373_ sky130_fd_sc_hd__xnor2_1
Xinput52 initial_freq[27] VGND VGND VPWR VPWR net52 sky130_fd_sc_hd__clkbuf_1
Xinput30 div_val[7] VGND VGND VPWR VPWR net30 sky130_fd_sc_hd__buf_1
X_1795_ _0256_ _0257_ VGND VGND VPWR VPWR _0258_ sky130_fd_sc_hd__and2_1
Xinput41 initial_freq[17] VGND VGND VPWR VPWR net41 sky130_fd_sc_hd__clkbuf_1
Xinput63 initial_freq[8] VGND VGND VPWR VPWR net63 sky130_fd_sc_hd__clkbuf_1
X_1864_ _0311_ _0313_ VGND VGND VPWR VPWR _0314_ sky130_fd_sc_hd__or2_1
XFILLER_29_228 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1229_ dco_inst.accumulator\[23\] net82 VGND VGND VPWR VPWR _0639_ sky130_fd_sc_hd__nor2_1
XFILLER_52_231 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_50_432 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_20_161 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1580_ _0975_ _0976_ _0978_ _0980_ VGND VGND VPWR VPWR _0981_ sky130_fd_sc_hd__o31a_1
XFILLER_7_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_7_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2132_ clknet_4_15_0_sys_clk _0035_ VGND VGND VPWR VPWR net100 sky130_fd_sc_hd__dfxtp_1
XFILLER_14_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2201_ clknet_4_6_0_sys_clk _0100_ VGND VGND VPWR VPWR net70 sky130_fd_sc_hd__dfxtp_1
X_2063_ _0482_ _0477_ _0280_ VGND VGND VPWR VPWR _0485_ sky130_fd_sc_hd__o21ai_1
XFILLER_34_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_34_286 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1847_ lf_inst.zero_error_count\[3\] net230 _0294_ lf_inst.zero_error_count\[4\]
+ VGND VGND VPWR VPWR _0300_ sky130_fd_sc_hd__a31o_1
X_1916_ _1032_ net137 VGND VGND VPWR VPWR _0358_ sky130_fd_sc_hd__and2_1
X_1778_ net349 net183 _0242_ _0243_ VGND VGND VPWR VPWR _0075_ sky130_fd_sc_hd__a211o_1
XFILLER_27_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_4_157 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_43_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_40_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_4_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_4_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_9_Left_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_16_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_18_237 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1701_ net212 lf_inst.integrator\[17\] VGND VGND VPWR VPWR _0175_ sky130_fd_sc_hd__xnor2_2
XFILLER_31_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_16_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1563_ _0847_ _0963_ VGND VGND VPWR VPWR _0964_ sky130_fd_sc_hd__or2_1
X_1494_ net16 _0863_ _0891_ _0894_ net310 VGND VGND VPWR VPWR _0895_ sky130_fd_sc_hd__o32a_1
X_1632_ lf_inst.integrator\[9\] _1010_ VGND VGND VPWR VPWR _1011_ sky130_fd_sc_hd__and2_1
XTAP_TAPCELL_ROW_1_138 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2115_ clknet_4_2_0_sys_clk _0018_ VGND VGND VPWR VPWR dco_inst.accumulator\[14\]
+ sky130_fd_sc_hd__dfxtp_1
X_2046_ net87 net186 _0266_ VGND VGND VPWR VPWR _0471_ sky130_fd_sc_hd__a21o_1
XFILLER_22_256 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_38_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_54_33 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_45_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_54_88 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_35_Left_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_9_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_15_218 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_48_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_51_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_48_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_36_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1546_ _0931_ _0944_ _0946_ VGND VGND VPWR VPWR _0947_ sky130_fd_sc_hd__nand3_1
Xfanout206 net207 VGND VGND VPWR VPWR net206 sky130_fd_sc_hd__buf_1
Xfanout217 net220 VGND VGND VPWR VPWR net217 sky130_fd_sc_hd__clkbuf_1
Xfanout228 lf_inst.error_in\[0\] VGND VGND VPWR VPWR net228 sky130_fd_sc_hd__buf_1
X_1615_ unlock_timer\[1\] _1000_ net209 VGND VGND VPWR VPWR _1002_ sky130_fd_sc_hd__a21boi_1
X_1477_ net24 _0877_ VGND VGND VPWR VPWR _0878_ sky130_fd_sc_hd__or2_1
Xfanout239 net240 VGND VGND VPWR VPWR net239 sky130_fd_sc_hd__buf_1
XPHY_EDGE_ROW_59_Left_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_37_354 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_27_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2029_ _0449_ _0455_ VGND VGND VPWR VPWR _0456_ sky130_fd_sc_hd__nand2_1
XFILLER_49_88 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_18_326 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_60_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_45_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_45_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1331_ net305 net249 VGND VGND VPWR VPWR _0732_ sky130_fd_sc_hd__and2_1
XFILLER_46_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1400_ div_inst.counter\[24\] _0797_ _0798_ _0800_ _0794_ VGND VGND VPWR VPWR _0801_
+ sky130_fd_sc_hd__a2111oi_1
X_1262_ dco_inst.accumulator\[27\] net86 VGND VGND VPWR VPWR _0668_ sky130_fd_sc_hd__nand2_1
Xinput6 div_val[14] VGND VGND VPWR VPWR net6 sky130_fd_sc_hd__dlymetal6s2s_1
X_1193_ _0581_ _0594_ _0595_ _0607_ VGND VGND VPWR VPWR _0608_ sky130_fd_sc_hd__o211ai_4
XFILLER_24_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_34_335 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1529_ _0925_ _0926_ VGND VGND VPWR VPWR _0930_ sky130_fd_sc_hd__nand2_1
XFILLER_42_104 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_14_Right_14 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_23_Right_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_2_277 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_48_416 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_18_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_32_Right_32 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_31_316 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1880_ lf_inst.integrator\[6\] net161 VGND VGND VPWR VPWR _0327_ sky130_fd_sc_hd__xnor2_1
XFILLER_44_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_41_Right_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1314_ net308 _0698_ VGND VGND VPWR VPWR _0715_ sky130_fd_sc_hd__and2_1
XPHY_EDGE_ROW_22_Left_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1245_ dco_inst.accumulator\[25\] net84 VGND VGND VPWR VPWR _0653_ sky130_fd_sc_hd__or2_1
XPHY_EDGE_ROW_50_Right_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1176_ _0578_ _0586_ _0587_ VGND VGND VPWR VPWR _0593_ sky130_fd_sc_hd__o21ba_1
XFILLER_21_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_46_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xinput31 div_val[8] VGND VGND VPWR VPWR net31 sky130_fd_sc_hd__buf_1
X_1863_ lf_inst.integrator\[3\] net164 VGND VGND VPWR VPWR _0313_ sky130_fd_sc_hd__nor2_1
XFILLER_14_170 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xinput20 div_val[27] VGND VGND VPWR VPWR net20 sky130_fd_sc_hd__buf_1
X_1932_ _1039_ net165 _0368_ VGND VGND VPWR VPWR _0372_ sky130_fd_sc_hd__a21oi_1
Xinput53 initial_freq[28] VGND VGND VPWR VPWR net53 sky130_fd_sc_hd__clkbuf_1
X_1794_ net225 lf_inst.integrator\[28\] VGND VGND VPWR VPWR _0257_ sky130_fd_sc_hd__nand2_1
Xinput42 initial_freq[18] VGND VGND VPWR VPWR net42 sky130_fd_sc_hd__clkbuf_1
Xinput64 initial_freq[9] VGND VGND VPWR VPWR net64 sky130_fd_sc_hd__clkbuf_1
X_1228_ net294 _0637_ _0638_ VGND VGND VPWR VPWR _0026_ sky130_fd_sc_hd__and3_1
XFILLER_52_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_50_433 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1159_ dco_inst.accumulator\[14\] net72 VGND VGND VPWR VPWR _0578_ sky130_fd_sc_hd__nand2_1
XFILLER_32_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_20_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_20_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_57_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_57_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_28_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_43_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_3_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2131_ clknet_4_15_0_sys_clk _0034_ VGND VGND VPWR VPWR dco_inst.accumulator\[30\]
+ sky130_fd_sc_hd__dfxtp_1
X_2062_ _0280_ _0477_ _0482_ VGND VGND VPWR VPWR _0484_ sky130_fd_sc_hd__or3_1
X_2200_ clknet_4_4_0_sys_clk _0099_ VGND VGND VPWR VPWR net69 sky130_fd_sc_hd__dfxtp_1
XFILLER_34_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_34_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1777_ net266 net50 VGND VGND VPWR VPWR _0243_ sky130_fd_sc_hd__and2_1
X_1846_ _0488_ _0287_ _0295_ _0298_ _0299_ VGND VGND VPWR VPWR _0087_ sky130_fd_sc_hd__o311a_1
X_1915_ _1032_ net136 VGND VGND VPWR VPWR _0357_ sky130_fd_sc_hd__nor2_1
XPHY_EDGE_ROW_4_Right_4 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_57_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_40_Left_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_40_257 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_48_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_16_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_18_238 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1700_ net366 net178 _0172_ _0173_ VGND VGND VPWR VPWR _0066_ sky130_fd_sc_hd__a211o_1
XFILLER_31_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1631_ net247 net228 VGND VGND VPWR VPWR _1010_ sky130_fd_sc_hd__and2b_1
X_1562_ net150 net148 div_inst.counter\[2\] VGND VGND VPWR VPWR _0963_ sky130_fd_sc_hd__a21oi_1
X_1493_ net139 _0862_ VGND VGND VPWR VPWR _0894_ sky130_fd_sc_hd__xnor2_1
X_2045_ _0464_ net127 _0468_ VGND VGND VPWR VPWR _0470_ sky130_fd_sc_hd__a21o_1
XTAP_TAPCELL_ROW_1_139 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2114_ clknet_4_7_0_sys_clk _0017_ VGND VGND VPWR VPWR dco_inst.accumulator\[13\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_22_268 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_22_279 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1829_ lf_inst.zero_error_count\[3\] lf_inst.zero_error_count\[2\] lf_inst.zero_error_count\[4\]
+ VGND VGND VPWR VPWR _0286_ sky130_fd_sc_hd__o21ai_1
XFILLER_57_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_13_202 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_15_219 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_48_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1614_ _1000_ _1001_ VGND VGND VPWR VPWR _0050_ sky130_fd_sc_hd__nor2_1
Xfanout218 net219 VGND VGND VPWR VPWR net218 sky130_fd_sc_hd__clkbuf_2
Xfanout207 net208 VGND VGND VPWR VPWR net207 sky130_fd_sc_hd__buf_1
X_1545_ _0943_ _0945_ _0934_ VGND VGND VPWR VPWR _0946_ sky130_fd_sc_hd__and3b_1
Xfanout229 lf_inst.sample_en VGND VGND VPWR VPWR net229 sky130_fd_sc_hd__buf_1
XFILLER_5_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1476_ _0868_ _0876_ VGND VGND VPWR VPWR _0877_ sky130_fd_sc_hd__or2_1
X_2028_ _0439_ _0442_ _0447_ VGND VGND VPWR VPWR _0455_ sky130_fd_sc_hd__or3_1
XTAP_TAPCELL_ROW_37_355 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_50_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_40_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_49_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_45_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_45_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_28_300 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_18_338 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1261_ dco_inst.accumulator\[27\] net86 VGND VGND VPWR VPWR _0667_ sky130_fd_sc_hd__and2_1
X_1330_ div_inst.counter\[3\] net249 _0730_ VGND VGND VPWR VPWR _0731_ sky130_fd_sc_hd__and3_1
XFILLER_36_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_36_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xinput7 div_val[15] VGND VGND VPWR VPWR net7 sky130_fd_sc_hd__buf_1
X_1192_ _0592_ _0601_ VGND VGND VPWR VPWR _0607_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_42_380 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_34_336 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_32_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1528_ net6 _0924_ _0928_ net302 VGND VGND VPWR VPWR _0929_ sky130_fd_sc_hd__a22oi_1
XFILLER_27_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1459_ div_inst.counter\[19\] net140 VGND VGND VPWR VPWR _0860_ sky130_fd_sc_hd__and2_1
XFILLER_19_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_42_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_51_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_4_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_48_417 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_18_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_33_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_31_317 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1244_ net295 _0651_ _0652_ VGND VGND VPWR VPWR _0028_ sky130_fd_sc_hd__and3_1
X_1313_ div_inst.counter\[13\] _0709_ _0713_ VGND VGND VPWR VPWR _0714_ sky130_fd_sc_hd__o21ai_1
X_1175_ _0590_ _0591_ VGND VGND VPWR VPWR _0592_ sky130_fd_sc_hd__nand2_1
XFILLER_32_160 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_20_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_46_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_46_13 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_46_263 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xinput54 initial_freq[29] VGND VGND VPWR VPWR net54 sky130_fd_sc_hd__clkbuf_1
Xinput32 div_val[9] VGND VGND VPWR VPWR net32 sky130_fd_sc_hd__buf_1
X_1793_ net221 lf_inst.integrator\[28\] VGND VGND VPWR VPWR _0256_ sky130_fd_sc_hd__or2_1
Xinput43 initial_freq[19] VGND VGND VPWR VPWR net43 sky130_fd_sc_hd__clkbuf_1
Xinput10 div_val[18] VGND VGND VPWR VPWR net10 sky130_fd_sc_hd__buf_1
X_1862_ _0306_ _0307_ _0305_ VGND VGND VPWR VPWR _0312_ sky130_fd_sc_hd__o21ai_1
Xinput21 div_val[28] VGND VGND VPWR VPWR net21 sky130_fd_sc_hd__buf_1
XFILLER_21_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1931_ _1044_ _0370_ VGND VGND VPWR VPWR _0371_ sky130_fd_sc_hd__xor2_1
Xinput65 ref_clk VGND VGND VPWR VPWR net65 sky130_fd_sc_hd__clkbuf_1
X_1227_ _0634_ _0635_ _0632_ VGND VGND VPWR VPWR _0638_ sky130_fd_sc_hd__o21bai_1
XFILLER_37_263 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1158_ dco_inst.accumulator\[14\] net72 VGND VGND VPWR VPWR _0577_ sky130_fd_sc_hd__or2_1
XFILLER_32_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1089_ _0518_ net282 _0517_ VGND VGND VPWR VPWR _0007_ sky130_fd_sc_hd__and3b_1
XFILLER_16_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_4_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_57_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2130_ clknet_4_15_0_sys_clk _0033_ VGND VGND VPWR VPWR dco_inst.accumulator\[29\]
+ sky130_fd_sc_hd__dfxtp_1
X_2061_ net350 net185 _0483_ net204 _0278_ VGND VGND VPWR VPWR _0118_ sky130_fd_sc_hd__a221o_1
XFILLER_19_263 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_34_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1914_ net368 net173 _0354_ _0356_ _1027_ VGND VGND VPWR VPWR _0098_ sky130_fd_sc_hd__a221o_1
XFILLER_19_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1776_ net196 _0241_ VGND VGND VPWR VPWR _0242_ sky130_fd_sc_hd__nor2_1
X_1845_ net296 _0288_ VGND VGND VPWR VPWR _0299_ sky130_fd_sc_hd__and2_1
XFILLER_8_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_40_269 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_16_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_16_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_17_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_18_239 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1630_ net298 net336 VGND VGND VPWR VPWR _0058_ sky130_fd_sc_hd__and2_1
X_1561_ net305 _0961_ VGND VGND VPWR VPWR _0962_ sky130_fd_sc_hd__nor2_1
XFILLER_3_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1492_ net17 _0889_ _0892_ net16 VGND VGND VPWR VPWR _0893_ sky130_fd_sc_hd__a22oi_1
X_2044_ _0464_ _0465_ _0468_ VGND VGND VPWR VPWR _0469_ sky130_fd_sc_hd__nand3_1
XFILLER_39_347 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2113_ clknet_4_7_0_sys_clk _0016_ VGND VGND VPWR VPWR dco_inst.accumulator\[12\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_13_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1759_ _0224_ _0225_ VGND VGND VPWR VPWR _0226_ sky130_fd_sc_hd__nand2_1
X_1828_ _0492_ _0285_ net259 VGND VGND VPWR VPWR _0083_ sky130_fd_sc_hd__a21oi_1
XFILLER_60_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_54_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_53_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_13_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_44_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1544_ _0936_ _0939_ _0940_ VGND VGND VPWR VPWR _0945_ sky130_fd_sc_hd__and3_1
X_1613_ _0489_ net348 _0999_ VGND VGND VPWR VPWR _1001_ sky130_fd_sc_hd__o21ai_1
Xfanout219 net220 VGND VGND VPWR VPWR net219 sky130_fd_sc_hd__clkbuf_1
Xfanout208 _1014_ VGND VGND VPWR VPWR net208 sky130_fd_sc_hd__buf_1
X_1475_ div_inst.counter\[29\] _0867_ VGND VGND VPWR VPWR _0876_ sky130_fd_sc_hd__nor2_1
XFILLER_54_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2027_ net156 _0249_ VGND VGND VPWR VPWR _0454_ sky130_fd_sc_hd__xnor2_2
XFILLER_42_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_24_38 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_24_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_49_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_45_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_45_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_28_301 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_18_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_60_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_53_180 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1260_ dco_inst.accumulator\[27\] net86 VGND VGND VPWR VPWR _0666_ sky130_fd_sc_hd__nor2_1
X_1191_ dco_inst.accumulator\[18\] net76 VGND VGND VPWR VPWR _0606_ sky130_fd_sc_hd__nand2_1
Xinput8 div_val[16] VGND VGND VPWR VPWR net8 sky130_fd_sc_hd__clkbuf_1
XFILLER_44_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_34_337 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_42_381 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1527_ net142 net132 VGND VGND VPWR VPWR _0928_ sky130_fd_sc_hd__xnor2_1
X_1458_ div_inst.counter\[17\] div_inst.counter\[16\] VGND VGND VPWR VPWR _0859_ sky130_fd_sc_hd__and2_1
X_1389_ div_inst.counter\[26\] _0789_ VGND VGND VPWR VPWR _0790_ sky130_fd_sc_hd__nor2_1
XFILLER_50_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_35_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_27_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_15_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_2_202 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_48_418 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_33_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_41_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkbuf_4_12_0_sys_clk clknet_0_sys_clk VGND VGND VPWR VPWR clknet_4_12_0_sys_clk
+ sky130_fd_sc_hd__clkbuf_8
XTAP_TAPCELL_ROW_31_318 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_14_342 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1243_ _0646_ _0650_ VGND VGND VPWR VPWR _0652_ sky130_fd_sc_hd__nand2_1
XFILLER_56_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1312_ net135 _0712_ net143 VGND VGND VPWR VPWR _0713_ sky130_fd_sc_hd__a21o_1
X_1174_ dco_inst.accumulator\[16\] net74 VGND VGND VPWR VPWR _0591_ sky130_fd_sc_hd__nand2_1
XFILLER_2_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_2_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_24_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_55_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_7_305 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_38_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_21_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1930_ net231 _1010_ net165 VGND VGND VPWR VPWR _0370_ sky130_fd_sc_hd__a21oi_1
Xinput66 rst_n VGND VGND VPWR VPWR net66 sky130_fd_sc_hd__clkbuf_1
X_1792_ lf_inst.integrator\[27\] net187 _0254_ net204 _0255_ VGND VGND VPWR VPWR _0077_
+ sky130_fd_sc_hd__a221o_1
Xinput11 div_val[19] VGND VGND VPWR VPWR net11 sky130_fd_sc_hd__buf_1
Xinput33 initial_freq[0] VGND VGND VPWR VPWR net33 sky130_fd_sc_hd__clkbuf_1
X_1861_ _0496_ net136 VGND VGND VPWR VPWR _0311_ sky130_fd_sc_hd__nor2_1
Xinput55 initial_freq[2] VGND VGND VPWR VPWR net55 sky130_fd_sc_hd__buf_1
Xinput44 initial_freq[1] VGND VGND VPWR VPWR net44 sky130_fd_sc_hd__clkbuf_1
Xinput22 div_val[29] VGND VGND VPWR VPWR net22 sky130_fd_sc_hd__dlymetal6s2s_1
X_1226_ _0630_ _0631_ _0634_ _0635_ VGND VGND VPWR VPWR _0637_ sky130_fd_sc_hd__a211o_1
X_1157_ _0574_ _0575_ _0576_ VGND VGND VPWR VPWR _0017_ sky130_fd_sc_hd__a21oi_1
X_1088_ _0514_ _0515_ _0516_ VGND VGND VPWR VPWR _0518_ sky130_fd_sc_hd__and3_1
XFILLER_20_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_57_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_43_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_28_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_7_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_7_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_11_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_22_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2060_ _0482_ _0481_ VGND VGND VPWR VPWR _0483_ sky130_fd_sc_hd__nor2_1
XFILLER_34_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1913_ net192 _0355_ VGND VGND VPWR VPWR _0356_ sky130_fd_sc_hd__nor2_1
X_1775_ _0239_ _0240_ VGND VGND VPWR VPWR _0241_ sky130_fd_sc_hd__and2_1
X_1844_ _0290_ _0294_ lf_inst.zero_error_count\[3\] VGND VGND VPWR VPWR _0298_ sky130_fd_sc_hd__a21o_1
XFILLER_57_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1209_ _0608_ _0620_ _0621_ VGND VGND VPWR VPWR _0622_ sky130_fd_sc_hd__a21o_1
X_2189_ clknet_4_6_0_sys_clk _0088_ VGND VGND VPWR VPWR lf_inst.zero_error_count\[4\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_25_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_4_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_4_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_26_284 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_16_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_17_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1560_ _0848_ _0960_ VGND VGND VPWR VPWR _0961_ sky130_fd_sc_hd__or2_1
X_1491_ _0863_ _0891_ VGND VGND VPWR VPWR _0892_ sky130_fd_sc_hd__or2_1
XFILLER_12_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2112_ clknet_4_5_0_sys_clk _0015_ VGND VGND VPWR VPWR dco_inst.accumulator\[11\]
+ sky130_fd_sc_hd__dfxtp_1
X_2043_ _0466_ _0467_ VGND VGND VPWR VPWR _0468_ sky130_fd_sc_hd__nand2_1
X_1827_ pfd_inst.state\[0\] pfd_inst.state\[2\] net215 VGND VGND VPWR VPWR _0285_
+ sky130_fd_sc_hd__or3b_1
XFILLER_13_18 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1758_ net216 lf_inst.integrator\[24\] VGND VGND VPWR VPWR _0225_ sky130_fd_sc_hd__nand2_1
X_1689_ _1048_ _0159_ VGND VGND VPWR VPWR _0164_ sky130_fd_sc_hd__or2_4
XFILLER_57_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_45_307 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_38_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_0_130 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_21_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_174 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1543_ net32 _0942_ VGND VGND VPWR VPWR _0944_ sky130_fd_sc_hd__or2_1
Xfanout209 _0999_ VGND VGND VPWR VPWR net209 sky130_fd_sc_hd__buf_1
X_1612_ _0489_ unlock_timer\[0\] VGND VGND VPWR VPWR _1000_ sky130_fd_sc_hd__and2_1
X_1474_ net22 _0874_ VGND VGND VPWR VPWR _0875_ sky130_fd_sc_hd__nand2_1
XFILLER_39_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2026_ _0249_ net157 VGND VGND VPWR VPWR _0453_ sky130_fd_sc_hd__nand2_1
XFILLER_10_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_60_118 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_53_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_30_71 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_59_482 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1190_ dco_inst.accumulator\[18\] net76 VGND VGND VPWR VPWR _0605_ sky130_fd_sc_hd__and2_1
Xinput9 div_val[17] VGND VGND VPWR VPWR net9 sky130_fd_sc_hd__buf_1
XFILLER_44_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_36_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_42_382 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1457_ net141 net142 net132 _0857_ VGND VGND VPWR VPWR _0858_ sky130_fd_sc_hd__and4_1
X_1526_ net281 _0920_ _0922_ net7 VGND VGND VPWR VPWR _0927_ sky130_fd_sc_hd__a22o_1
XFILLER_19_17 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_35_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_27_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1388_ net19 _0769_ VGND VGND VPWR VPWR _0789_ sky130_fd_sc_hd__xnor2_1
XFILLER_51_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_51_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2009_ _0221_ net154 _0437_ VGND VGND VPWR VPWR _0438_ sky130_fd_sc_hd__o21a_1
XFILLER_2_214 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_48_419 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_18_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_41_140 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_26_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_14_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_31_319 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_51_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1311_ net3 net308 _0698_ net4 VGND VGND VPWR VPWR _0712_ sky130_fd_sc_hd__o31ai_1
X_1242_ _0646_ _0650_ VGND VGND VPWR VPWR _0651_ sky130_fd_sc_hd__or2_1
XFILLER_49_295 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1173_ dco_inst.accumulator\[16\] net74 VGND VGND VPWR VPWR _0590_ sky130_fd_sc_hd__or2_1
XFILLER_2_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_10_Right_10 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_32_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1509_ net11 _0902_ _0907_ VGND VGND VPWR VPWR _0910_ sky130_fd_sc_hd__or3_1
XFILLER_7_317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_11_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_26_Left_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1860_ _0308_ _0309_ _0310_ VGND VGND VPWR VPWR _0090_ sky130_fd_sc_hd__o21ai_1
Xinput56 initial_freq[30] VGND VGND VPWR VPWR net56 sky130_fd_sc_hd__clkbuf_1
X_1791_ net267 net52 VGND VGND VPWR VPWR _0255_ sky130_fd_sc_hd__and2_1
Xinput45 initial_freq[20] VGND VGND VPWR VPWR net45 sky130_fd_sc_hd__clkbuf_1
Xinput12 div_val[1] VGND VGND VPWR VPWR net12 sky130_fd_sc_hd__clkbuf_1
Xinput23 div_val[2] VGND VGND VPWR VPWR net23 sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_6_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xinput34 initial_freq[10] VGND VGND VPWR VPWR net34 sky130_fd_sc_hd__clkbuf_1
X_1225_ _0635_ VGND VGND VPWR VPWR _0636_ sky130_fd_sc_hd__inv_2
XFILLER_37_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_37_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1087_ _0514_ _0515_ _0516_ VGND VGND VPWR VPWR _0517_ sky130_fd_sc_hd__a21o_1
XFILLER_16_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1156_ _0574_ _0575_ net291 VGND VGND VPWR VPWR _0576_ sky130_fd_sc_hd__o21ai_1
X_1989_ _0208_ net153 VGND VGND VPWR VPWR _0421_ sky130_fd_sc_hd__or2_1
XFILLER_4_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_57_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_28_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_43_202 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_19_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_34_268 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1843_ net297 _0296_ _0297_ VGND VGND VPWR VPWR _0086_ sky130_fd_sc_hd__and3_1
XFILLER_8_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_8_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1912_ _0346_ _0349_ _0353_ VGND VGND VPWR VPWR _0355_ sky130_fd_sc_hd__o21a_1
X_1774_ _0225_ _0231_ _0237_ VGND VGND VPWR VPWR _0240_ sky130_fd_sc_hd__a21o_1
XFILLER_8_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_57_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_57_305 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1208_ _0604_ _0614_ _0612_ VGND VGND VPWR VPWR _0621_ sky130_fd_sc_hd__a21o_1
XFILLER_27_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2188_ clknet_4_12_0_sys_clk _0087_ VGND VGND VPWR VPWR lf_inst.zero_error_count\[3\]
+ sky130_fd_sc_hd__dfxtp_1
X_1139_ _0559_ _0560_ VGND VGND VPWR VPWR _0561_ sky130_fd_sc_hd__nand2b_1
XFILLER_48_316 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_48_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_3_150 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_33_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_26_285 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_3_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1490_ net139 _0862_ div_inst.counter\[22\] VGND VGND VPWR VPWR _0891_ sky130_fd_sc_hd__a21oi_1
XFILLER_54_319 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2042_ _0264_ net158 VGND VGND VPWR VPWR _0467_ sky130_fd_sc_hd__nand2_1
X_2111_ clknet_4_5_0_sys_clk _0014_ VGND VGND VPWR VPWR dco_inst.accumulator\[10\]
+ sky130_fd_sc_hd__dfxtp_1
XPHY_EDGE_ROW_8_Right_8 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_17_230 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_22_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1826_ net316 net347 _0284_ net291 VGND VGND VPWR VPWR _0082_ sky130_fd_sc_hd__o31a_1
XPHY_EDGE_ROW_29_Left_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_39_Right_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1757_ net217 lf_inst.integrator\[24\] VGND VGND VPWR VPWR _0224_ sky130_fd_sc_hd__or2_1
XFILLER_38_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1688_ lf_inst.integrator\[15\] net172 _0162_ _0163_ VGND VGND VPWR VPWR _0065_ sky130_fd_sc_hd__a211o_1
XFILLER_1_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_13_Left_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_57_124 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_57_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_54_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_0_131 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_48_Right_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_9_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_23_266 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_57_Right_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_56_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_36_319 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_8_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1611_ net99 net252 VGND VGND VPWR VPWR _0999_ sky130_fd_sc_hd__nor2_1
X_1542_ net2 _0938_ _0942_ net32 VGND VGND VPWR VPWR _0943_ sky130_fd_sc_hd__a22o_1
X_1473_ _0867_ _0873_ VGND VGND VPWR VPWR _0874_ sky130_fd_sc_hd__or2_1
X_2025_ _0249_ net157 VGND VGND VPWR VPWR _0452_ sky130_fd_sc_hd__nor2_1
XFILLER_27_308 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_50_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_24_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1809_ _0269_ _0270_ VGND VGND VPWR VPWR _0271_ sky130_fd_sc_hd__xnor2_1
XFILLER_41_311 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_30_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_59_483 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_36_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_44_171 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_42_383 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_59_208 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1525_ net281 _0920_ _0922_ net7 VGND VGND VPWR VPWR _0926_ sky130_fd_sc_hd__a22oi_1
X_1456_ div_inst.counter\[15\] div_inst.counter\[14\] VGND VGND VPWR VPWR _0857_ sky130_fd_sc_hd__and2_1
X_1387_ _0771_ _0787_ div_inst.counter\[27\] VGND VGND VPWR VPWR _0788_ sky130_fd_sc_hd__o21ba_1
XFILLER_19_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2008_ _0203_ _0208_ _0216_ net154 VGND VGND VPWR VPWR _0437_ sky130_fd_sc_hd__a31o_1
XFILLER_35_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_23_322 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_23_311 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_50_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_2_226 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_56_464 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_33_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_26_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_47_Left_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_41_71 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1241_ _0648_ _0649_ VGND VGND VPWR VPWR _0650_ sky130_fd_sc_hd__nand2_1
X_1310_ _0710_ _0707_ VGND VGND VPWR VPWR _0711_ sky130_fd_sc_hd__and2b_1
XFILLER_1_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_56_Left_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1172_ net285 _0588_ _0589_ VGND VGND VPWR VPWR _0019_ sky130_fd_sc_hd__and3_1
XFILLER_20_325 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_21_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xoutput100 net239 VGND VGND VPWR VPWR pll_out sky130_fd_sc_hd__buf_2
XFILLER_46_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1508_ _0902_ _0907_ net11 VGND VGND VPWR VPWR _0909_ sky130_fd_sc_hd__o21ai_1
X_1439_ _0786_ _0836_ _0839_ _0775_ VGND VGND VPWR VPWR _0840_ sky130_fd_sc_hd__a22o_1
XFILLER_11_314 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_15_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_23_152 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_7_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_2_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_46_200 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_1_Left_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1790_ _0252_ _0253_ VGND VGND VPWR VPWR _0254_ sky130_fd_sc_hd__xnor2_2
XFILLER_14_174 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xinput13 div_val[20] VGND VGND VPWR VPWR net13 sky130_fd_sc_hd__clkbuf_1
Xinput57 initial_freq[31] VGND VGND VPWR VPWR net57 sky130_fd_sc_hd__clkbuf_1
Xinput46 initial_freq[21] VGND VGND VPWR VPWR net46 sky130_fd_sc_hd__clkbuf_1
Xinput35 initial_freq[11] VGND VGND VPWR VPWR net35 sky130_fd_sc_hd__clkbuf_1
Xinput24 div_val[30] VGND VGND VPWR VPWR net24 sky130_fd_sc_hd__dlymetal6s2s_1
X_1224_ _0618_ _0626_ _0625_ VGND VGND VPWR VPWR _0635_ sky130_fd_sc_hd__a21boi_2
X_1086_ _0510_ _0511_ _0509_ VGND VGND VPWR VPWR _0516_ sky130_fd_sc_hd__a21bo_1
XFILLER_16_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1155_ _0567_ _0570_ _0569_ VGND VGND VPWR VPWR _0575_ sky130_fd_sc_hd__a21bo_1
X_1988_ _0412_ _0418_ VGND VGND VPWR VPWR _0420_ sky130_fd_sc_hd__nand2_1
XFILLER_32_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_32_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_57_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_43_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_43_247 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_11_100 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout190 _1017_ VGND VGND VPWR VPWR net190 sky130_fd_sc_hd__buf_1
X_1773_ _0225_ _0231_ _0237_ VGND VGND VPWR VPWR _0239_ sky130_fd_sc_hd__nand3_1
X_1842_ lf_inst.zero_error_count\[1\] lf_inst.zero_error_count\[0\] lf_inst.zero_error_count\[2\]
+ VGND VGND VPWR VPWR _0297_ sky130_fd_sc_hd__a21o_1
XFILLER_8_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1911_ _0346_ _0349_ _0353_ VGND VGND VPWR VPWR _0354_ sky130_fd_sc_hd__or3_1
XFILLER_6_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_57_317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1207_ _0606_ _0612_ _0614_ _0609_ VGND VGND VPWR VPWR _0620_ sky130_fd_sc_hd__o211a_1
X_2187_ clknet_4_13_0_sys_clk _0086_ VGND VGND VPWR VPWR lf_inst.zero_error_count\[2\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_27_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_43_28 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_25_258 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_25_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_25_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1138_ dco_inst.accumulator\[11\] net69 VGND VGND VPWR VPWR _0560_ sky130_fd_sc_hd__nand2_1
X_1069_ _0049_ VGND VGND VPWR VPWR _0003_ sky130_fd_sc_hd__inv_2
XFILLER_4_118 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_48_339 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_56_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_3_151 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_16_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_33_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_26_286 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2041_ _0264_ net158 VGND VGND VPWR VPWR _0466_ sky130_fd_sc_hd__or2_1
X_2110_ clknet_4_5_0_sys_clk _0013_ VGND VGND VPWR VPWR dco_inst.accumulator\[9\]
+ sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_17_231 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1756_ net342 net181 _0222_ _0223_ VGND VGND VPWR VPWR _0073_ sky130_fd_sc_hd__a211o_1
XFILLER_30_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1825_ pfd_inst.state\[0\] lf_inst.error_in\[0\] VGND VGND VPWR VPWR _0284_ sky130_fd_sc_hd__and2b_1
X_1687_ net252 net39 VGND VGND VPWR VPWR _0163_ sky130_fd_sc_hd__and2_1
XFILLER_57_136 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_54_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_54_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_0_132 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_13_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2239_ net239 _0138_ VGND VGND VPWR VPWR div_inst.counter\[18\] sky130_fd_sc_hd__dfxtp_1
XFILLER_21_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_21_294 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_23_267 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_29_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_14_212 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_60_70 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_30_Left_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_8_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_8_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1610_ net33 net233 net284 VGND VGND VPWR VPWR _0048_ sky130_fd_sc_hd__mux2_1
X_1541_ _0851_ _0941_ VGND VGND VPWR VPWR _0942_ sky130_fd_sc_hd__or2_1
XFILLER_5_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_5_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1472_ div_inst.counter\[27\] _0866_ div_inst.counter\[28\] VGND VGND VPWR VPWR _0873_
+ sky130_fd_sc_hd__a21oi_1
X_2024_ net340 net183 _0451_ net207 _0243_ VGND VGND VPWR VPWR _0113_ sky130_fd_sc_hd__a221o_1
XFILLER_39_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_35_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_24_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1739_ net196 _0208_ VGND VGND VPWR VPWR _0209_ sky130_fd_sc_hd__nor2_1
X_1808_ _0257_ _0263_ VGND VGND VPWR VPWR _0270_ sky130_fd_sc_hd__nand2_1
XFILLER_40_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_20_248 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_18_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_53_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_41_323 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_202 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_5_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_59_484 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_55_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_51_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_42_384 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_32_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_32_312 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1524_ net7 _0922_ _0924_ net6 _0921_ VGND VGND VPWR VPWR _0925_ sky130_fd_sc_hd__o221a_1
X_1455_ net141 net142 net132 VGND VGND VPWR VPWR _0856_ sky130_fd_sc_hd__and3_1
X_1386_ net19 net309 _0768_ net20 VGND VGND VPWR VPWR _0787_ sky130_fd_sc_hd__o31a_1
X_2007_ _0417_ _0416_ _0423_ _0414_ _0227_ VGND VGND VPWR VPWR _0436_ sky130_fd_sc_hd__a2111o_1
XFILLER_50_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_50_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_2_238 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_58_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_56_465 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_33_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_25_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_14_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_41_83 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_49_264 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_49_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1240_ _0608_ _0620_ _0621_ _0633_ _0647_ VGND VGND VPWR VPWR _0649_ sky130_fd_sc_hd__a2111o_1
XFILLER_1_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1171_ _0578_ _0584_ _0586_ _0587_ VGND VGND VPWR VPWR _0589_ sky130_fd_sc_hd__a211o_1
XTAP_TAPCELL_ROW_47_410 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_24_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_32_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_30_310 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_20_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1507_ _0902_ _0907_ VGND VGND VPWR VPWR _0908_ sky130_fd_sc_hd__or2_1
XFILLER_55_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1369_ net20 net19 net309 _0768_ VGND VGND VPWR VPWR _0770_ sky130_fd_sc_hd__or4_2
X_1438_ _0777_ _0785_ _0837_ _0838_ VGND VGND VPWR VPWR _0839_ sky130_fd_sc_hd__o31ai_1
XTAP_TAPCELL_ROW_53_446 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_23_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_23_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_11_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_46_212 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_36_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_52_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xinput14 div_val[21] VGND VGND VPWR VPWR net14 sky130_fd_sc_hd__buf_1
Xinput25 div_val[31] VGND VGND VPWR VPWR net25 sky130_fd_sc_hd__buf_1
Xinput36 initial_freq[12] VGND VGND VPWR VPWR net36 sky130_fd_sc_hd__clkbuf_1
XFILLER_14_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xinput47 initial_freq[22] VGND VGND VPWR VPWR net47 sky130_fd_sc_hd__clkbuf_1
Xinput58 initial_freq[3] VGND VGND VPWR VPWR net58 sky130_fd_sc_hd__clkbuf_1
X_1223_ _0622_ _0633_ VGND VGND VPWR VPWR _0634_ sky130_fd_sc_hd__nor2_1
XFILLER_37_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1154_ _0572_ _0573_ VGND VGND VPWR VPWR _0574_ sky130_fd_sc_hd__and2b_1
XFILLER_60_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_52_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1085_ dco_inst.accumulator\[3\] net92 VGND VGND VPWR VPWR _0515_ sky130_fd_sc_hd__or2_1
X_1987_ net353 net181 _0418_ _0419_ _0205_ VGND VGND VPWR VPWR _0108_ sky130_fd_sc_hd__a221o_1
XFILLER_9_190 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_57_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_43_259 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_43_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_51_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_22_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout180 net184 VGND VGND VPWR VPWR net180 sky130_fd_sc_hd__buf_1
Xfanout191 net192 VGND VGND VPWR VPWR net191 sky130_fd_sc_hd__clkbuf_2
XFILLER_19_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1910_ _0351_ _0352_ VGND VGND VPWR VPWR _0353_ sky130_fd_sc_hd__nor2_1
XFILLER_19_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1772_ _0237_ VGND VGND VPWR VPWR _0238_ sky130_fd_sc_hd__inv_2
XFILLER_42_292 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1841_ lf_inst.zero_error_count\[2\] _0289_ net133 _0295_ VGND VGND VPWR VPWR _0296_
+ sky130_fd_sc_hd__a22o_1
XFILLER_6_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_8_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_57_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1206_ _0617_ _0618_ VGND VGND VPWR VPWR _0619_ sky130_fd_sc_hd__nand2_1
X_2186_ clknet_4_13_0_sys_clk net364 VGND VGND VPWR VPWR lf_inst.zero_error_count\[1\]
+ sky130_fd_sc_hd__dfxtp_1
X_1137_ dco_inst.accumulator\[11\] net69 VGND VGND VPWR VPWR _0559_ sky130_fd_sc_hd__nor2_1
XFILLER_33_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1068_ net99 _0489_ net285 VGND VGND VPWR VPWR _0049_ sky130_fd_sc_hd__o21a_1
XTAP_TAPCELL_ROW_26_287 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_16_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_24_292 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2040_ _0254_ _0397_ _0439_ _0447_ _0452_ VGND VGND VPWR VPWR _0465_ sky130_fd_sc_hd__a2111oi_2
Xhold3 pfd_inst.ref_sync\[0\] VGND VGND VPWR VPWR net313 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_15_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_17_232 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1755_ net267 net48 VGND VGND VPWR VPWR _0223_ sky130_fd_sc_hd__and2_1
X_1824_ net325 net185 _0281_ _0282_ _0283_ VGND VGND VPWR VPWR _0081_ sky130_fd_sc_hd__a221o_1
Xmax_cap133 _0290_ VGND VGND VPWR VPWR net133 sky130_fd_sc_hd__buf_1
XFILLER_30_295 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1686_ net191 _0161_ VGND VGND VPWR VPWR _0162_ sky130_fd_sc_hd__nor2_1
XFILLER_57_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_38_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2238_ net236 _0137_ VGND VGND VPWR VPWR div_inst.counter\[17\] sky130_fd_sc_hd__dfxtp_1
XFILLER_53_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2169_ clknet_4_8_0_sys_clk _0069_ VGND VGND VPWR VPWR lf_inst.integrator\[19\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_0_133 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_122 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_23_268 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_56_170 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_48_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_28_95 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_44_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_44_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_44_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_8_211 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_12_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_14_213 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_60_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_60_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1540_ net144 _0850_ div_inst.counter\[8\] VGND VGND VPWR VPWR _0941_ sky130_fd_sc_hd__a21oi_1
XFILLER_8_222 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_39_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_10_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1471_ net25 _0871_ VGND VGND VPWR VPWR _0872_ sky130_fd_sc_hd__nand2_1
X_2023_ _0446_ _0450_ VGND VGND VPWR VPWR _0451_ sky130_fd_sc_hd__xnor2_1
X_1807_ _0267_ _0268_ VGND VGND VPWR VPWR _0269_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_20_249 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1738_ _0206_ _0207_ VGND VGND VPWR VPWR _0208_ sky130_fd_sc_hd__xnor2_2
X_1669_ _1042_ _1043_ VGND VGND VPWR VPWR _1044_ sky130_fd_sc_hd__xnor2_2
XFILLER_26_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_53_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_41_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_41_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_5_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_14_64 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_59_485 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_17_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_42_385 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_58_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1454_ net144 net134 _0852_ _0854_ VGND VGND VPWR VPWR _0855_ sky130_fd_sc_hd__and4_1
X_1523_ _0856_ _0923_ VGND VGND VPWR VPWR _0924_ sky130_fd_sc_hd__or2_1
X_1385_ _0782_ _0785_ _0783_ _0775_ VGND VGND VPWR VPWR _0786_ sky130_fd_sc_hd__and4bb_1
X_2006_ net369 net182 _0434_ _0435_ _0223_ VGND VGND VPWR VPWR _0111_ sky130_fd_sc_hd__a221o_1
XFILLER_35_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_33_330 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_23_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_58_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_56_466 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_25_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_41_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_25_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_41_95 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_49_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_47_411 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_1_261 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1170_ _0586_ _0587_ _0578_ _0584_ VGND VGND VPWR VPWR _0588_ sky130_fd_sc_hd__o211ai_1
XFILLER_17_195 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_30_311 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_9_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1506_ net130 net138 net140 VGND VGND VPWR VPWR _0907_ sky130_fd_sc_hd__a21oi_1
X_1437_ div_inst.counter\[31\] _0774_ _0784_ div_inst.counter\[30\] VGND VGND VPWR
+ VPWR _0838_ sky130_fd_sc_hd__o22a_1
XFILLER_55_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_55_235 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_46_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1299_ net4 net3 net308 _0698_ VGND VGND VPWR VPWR _0700_ sky130_fd_sc_hd__or4_1
X_1368_ net309 _0768_ VGND VGND VPWR VPWR _0769_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_53_447 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_46_224 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_14_110 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xinput48 initial_freq[23] VGND VGND VPWR VPWR net48 sky130_fd_sc_hd__clkbuf_1
Xinput26 div_val[3] VGND VGND VPWR VPWR net26 sky130_fd_sc_hd__buf_1
Xinput59 initial_freq[4] VGND VGND VPWR VPWR net59 sky130_fd_sc_hd__clkbuf_1
Xinput37 initial_freq[13] VGND VGND VPWR VPWR net37 sky130_fd_sc_hd__clkbuf_1
Xinput15 div_val[22] VGND VGND VPWR VPWR net15 sky130_fd_sc_hd__clkbuf_1
XFILLER_42_6 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1222_ _0619_ _0627_ VGND VGND VPWR VPWR _0633_ sky130_fd_sc_hd__or2_1
X_1084_ dco_inst.accumulator\[3\] net92 VGND VGND VPWR VPWR _0514_ sky130_fd_sc_hd__nand2_1
X_1153_ dco_inst.accumulator\[13\] net71 VGND VGND VPWR VPWR _0573_ sky130_fd_sc_hd__nand2_1
XFILLER_60_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_50_428 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1986_ _0414_ _0416_ _0417_ net196 VGND VGND VPWR VPWR _0419_ sky130_fd_sc_hd__a31oi_1
XFILLER_20_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_20_146 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_57_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_51_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_7_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_11_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xfanout181 net183 VGND VGND VPWR VPWR net181 sky130_fd_sc_hd__dlymetal6s2s_1
Xfanout192 net199 VGND VGND VPWR VPWR net192 sky130_fd_sc_hd__clkbuf_2
X_1840_ _0294_ VGND VGND VPWR VPWR _0295_ sky130_fd_sc_hd__inv_2
X_1771_ _0235_ _0236_ VGND VGND VPWR VPWR _0237_ sky130_fd_sc_hd__and2_1
XFILLER_6_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_8_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_40_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2254_ net233 VGND VGND VPWR VPWR net67 sky130_fd_sc_hd__clkbuf_1
X_1205_ dco_inst.accumulator\[20\] net79 VGND VGND VPWR VPWR _0618_ sky130_fd_sc_hd__nand2_1
X_2185_ clknet_4_12_0_sys_clk _0084_ VGND VGND VPWR VPWR lf_inst.zero_error_count\[0\]
+ sky130_fd_sc_hd__dfxtp_1
X_1067_ net288 _0497_ _0502_ VGND VGND VPWR VPWR _0002_ sky130_fd_sc_hd__and3_1
X_1136_ net287 _0557_ _0558_ VGND VGND VPWR VPWR _0014_ sky130_fd_sc_hd__and3_1
X_1969_ _0402_ _0403_ _0401_ VGND VGND VPWR VPWR _0404_ sky130_fd_sc_hd__a21o_1
XFILLER_0_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_26_288 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold4 pfd_inst.fb_sync\[0\] VGND VGND VPWR VPWR net314 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_17_233 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1823_ net273 net57 VGND VGND VPWR VPWR _0283_ sky130_fd_sc_hd__and2_1
XFILLER_22_208 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1754_ net196 _0221_ VGND VGND VPWR VPWR _0222_ sky130_fd_sc_hd__nor2_1
X_1685_ _0159_ _0160_ VGND VGND VPWR VPWR _0161_ sky130_fd_sc_hd__xor2_2
XFILLER_38_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2237_ net236 _0136_ VGND VGND VPWR VPWR div_inst.counter\[16\] sky130_fd_sc_hd__dfxtp_1
XFILLER_54_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_53_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2168_ clknet_4_9_0_sys_clk _0068_ VGND VGND VPWR VPWR lf_inst.integrator\[18\] sky130_fd_sc_hd__dfxtp_1
X_2099_ net99 _0487_ _0299_ VGND VGND VPWR VPWR _0152_ sky130_fd_sc_hd__o21a_1
XTAP_TAPCELL_ROW_0_123 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1119_ _0535_ _0539_ _0543_ VGND VGND VPWR VPWR _0544_ sky130_fd_sc_hd__a21o_1
Xclkbuf_4_1_0_sys_clk clknet_0_sys_clk VGND VGND VPWR VPWR clknet_4_1_0_sys_clk sky130_fd_sc_hd__clkbuf_8
XPHY_EDGE_ROW_17_Right_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_23_269 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_48_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_26_Right_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_56_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_28_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_28_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_35_Right_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_8_234 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_14_214 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1470_ _0869_ _0870_ VGND VGND VPWR VPWR _0871_ sky130_fd_sc_hd__nand2_1
XPHY_EDGE_ROW_44_Right_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_53_Right_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_50_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2022_ _0447_ _0448_ VGND VGND VPWR VPWR _0450_ sky130_fd_sc_hd__nor2_1
XFILLER_35_355 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1806_ net222 lf_inst.integrator\[29\] VGND VGND VPWR VPWR _0268_ sky130_fd_sc_hd__nand2_1
XPHY_EDGE_ROW_17_Left_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1737_ _0200_ _0202_ _0199_ VGND VGND VPWR VPWR _0207_ sky130_fd_sc_hd__a21o_1
X_1668_ _1029_ _1036_ _1037_ _1035_ VGND VGND VPWR VPWR _1043_ sky130_fd_sc_hd__o31a_1
X_1599_ net250 net58 VGND VGND VPWR VPWR _0997_ sky130_fd_sc_hd__and2_1
XFILLER_26_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_14_10 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_14_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_5_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_59_486 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_44_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_17_355 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1453_ div_inst.counter\[11\] div_inst.counter\[10\] VGND VGND VPWR VPWR _0854_ sky130_fd_sc_hd__and2_1
X_1522_ net142 net132 net141 VGND VGND VPWR VPWR _0923_ sky130_fd_sc_hd__a21oi_1
X_2005_ _0432_ _0433_ net203 VGND VGND VPWR VPWR _0435_ sky130_fd_sc_hd__o21a_1
X_1384_ div_inst.counter\[30\] _0784_ VGND VGND VPWR VPWR _0785_ sky130_fd_sc_hd__xnor2_1
XFILLER_50_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_50_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_50_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_33_331 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_58_277 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_56_467 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_41_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_47_412 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_1_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_32_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_30_312 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_17_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_20_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1505_ _0861_ _0903_ _0494_ VGND VGND VPWR VPWR _0906_ sky130_fd_sc_hd__a21o_1
X_1367_ net17 net16 net310 net129 VGND VGND VPWR VPWR _0768_ sky130_fd_sc_hd__or4_2
X_1436_ _0778_ _0781_ VGND VGND VPWR VPWR _0837_ sky130_fd_sc_hd__nor2_1
XFILLER_55_247 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_53_448 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_46_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_43_Left_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1298_ net308 _0698_ VGND VGND VPWR VPWR _0699_ sky130_fd_sc_hd__nor2_1
XFILLER_11_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_52_Left_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_11_88 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_46_236 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_52_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_36_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_14_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xinput27 div_val[4] VGND VGND VPWR VPWR net27 sky130_fd_sc_hd__clkbuf_1
Xinput49 initial_freq[24] VGND VGND VPWR VPWR net49 sky130_fd_sc_hd__buf_1
Xinput38 initial_freq[14] VGND VGND VPWR VPWR net38 sky130_fd_sc_hd__clkbuf_1
XFILLER_6_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xinput16 div_val[23] VGND VGND VPWR VPWR net16 sky130_fd_sc_hd__dlymetal6s2s_1
X_1221_ _0630_ _0631_ VGND VGND VPWR VPWR _0632_ sky130_fd_sc_hd__nand2_1
XFILLER_37_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1083_ _0513_ net284 _0512_ VGND VGND VPWR VPWR _0006_ sky130_fd_sc_hd__and3b_1
X_1152_ dco_inst.accumulator\[13\] net71 VGND VGND VPWR VPWR _0572_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_50_429 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1985_ _0416_ _0417_ _0414_ VGND VGND VPWR VPWR _0418_ sky130_fd_sc_hd__a21o_1
X_1419_ div_inst.counter\[18\] _0818_ _0819_ div_inst.counter\[17\] VGND VGND VPWR
+ VPWR _0820_ sky130_fd_sc_hd__a22oi_2
XFILLER_51_261 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_11_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_5_Left_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_3_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_59_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout182 net183 VGND VGND VPWR VPWR net182 sky130_fd_sc_hd__buf_1
Xfanout160 _0397_ VGND VGND VPWR VPWR net160 sky130_fd_sc_hd__clkbuf_2
Xfanout193 net195 VGND VGND VPWR VPWR net193 sky130_fd_sc_hd__dlymetal6s2s_1
Xfanout171 net177 VGND VGND VPWR VPWR net171 sky130_fd_sc_hd__clkbuf_2
XFILLER_19_203 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_19_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_19_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1770_ net217 lf_inst.integrator\[25\] VGND VGND VPWR VPWR _0236_ sky130_fd_sc_hd__nand2_1
X_1204_ dco_inst.accumulator\[20\] net79 VGND VGND VPWR VPWR _0617_ sky130_fd_sc_hd__or2_1
XFILLER_33_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2253_ clknet_4_6_0_sys_clk _0152_ VGND VGND VPWR VPWR net99 sky130_fd_sc_hd__dfxtp_1
X_2184_ clknet_4_7_0_sys_clk _0083_ VGND VGND VPWR VPWR lf_inst.error_in\[1\] sky130_fd_sc_hd__dfxtp_2
XFILLER_40_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1066_ pfd_inst.ref_sync\[1\] _0491_ pfd_inst.state\[0\] pfd_inst.state\[2\] VGND
+ VGND VPWR VPWR _0502_ sky130_fd_sc_hd__a31o_1
X_1135_ _0553_ _0556_ VGND VGND VPWR VPWR _0558_ sky130_fd_sc_hd__or2_1
X_1968_ _0386_ _0387_ _0388_ _0393_ _0385_ VGND VGND VPWR VPWR _0403_ sky130_fd_sc_hd__a311o_1
X_1899_ _0338_ _0341_ _0343_ VGND VGND VPWR VPWR _0344_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_17_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_33_31 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_26_289 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_24_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_39_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xhold5 lf_inst.integrator\[10\] VGND VGND VPWR VPWR net315 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_15_261 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_17_234 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1822_ net222 _0280_ net198 VGND VGND VPWR VPWR _0282_ sky130_fd_sc_hd__a21oi_1
X_1753_ _0219_ _0220_ VGND VGND VPWR VPWR _0221_ sky130_fd_sc_hd__xnor2_1
XFILLER_30_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_30_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1684_ _1047_ _0154_ VGND VGND VPWR VPWR _0160_ sky130_fd_sc_hd__nand2_1
X_2167_ clknet_4_9_0_sys_clk _0067_ VGND VGND VPWR VPWR lf_inst.integrator\[17\] sky130_fd_sc_hd__dfxtp_1
X_2236_ net245 _0135_ VGND VGND VPWR VPWR div_inst.counter\[15\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_0_124 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2098_ lf_inst.zero_error_count\[3\] lf_inst.zero_error_count\[2\] net230 lf_inst.zero_error_count\[4\]
+ VGND VGND VPWR VPWR _0487_ sky130_fd_sc_hd__o211a_1
X_1118_ _0541_ _0542_ VGND VGND VPWR VPWR _0543_ sky130_fd_sc_hd__nand2_1
Xclkbuf_4_5_0_sys_clk clknet_0_sys_clk VGND VGND VPWR VPWR clknet_4_5_0_sys_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_146 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_44_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_29_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_28_64 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_28_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_44_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_8_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_12_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_12_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_14_215 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2021_ _0241_ net156 VGND VGND VPWR VPWR _0449_ sky130_fd_sc_hd__nand2_1
X_1805_ net222 lf_inst.integrator\[29\] VGND VGND VPWR VPWR _0267_ sky130_fd_sc_hd__or2_1
X_1736_ net218 lf_inst.integrator\[21\] VGND VGND VPWR VPWR _0206_ sky130_fd_sc_hd__xor2_2
X_1667_ _1041_ lf_inst.integrator\[13\] VGND VGND VPWR VPWR _1042_ sky130_fd_sc_hd__xnor2_4
X_1598_ net55 net339 net283 VGND VGND VPWR VPWR _0038_ sky130_fd_sc_hd__mux2_1
X_2219_ clknet_4_15_0_sys_clk _0118_ VGND VGND VPWR VPWR net90 sky130_fd_sc_hd__dfxtp_1
XFILLER_45_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_38_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_26_345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_41_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_14_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_5_249 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_59_487 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_34_Left_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1452_ net144 net134 _0852_ VGND VGND VPWR VPWR _0853_ sky130_fd_sc_hd__and3_1
X_1521_ div_inst.counter\[14\] _0856_ VGND VGND VPWR VPWR _0922_ sky130_fd_sc_hd__xnor2_2
X_1383_ net24 _0772_ VGND VGND VPWR VPWR _0784_ sky130_fd_sc_hd__xor2_1
X_2004_ _0432_ _0433_ VGND VGND VPWR VPWR _0434_ sky130_fd_sc_hd__nand2_1
XFILLER_35_120 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_35_186 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_23_348 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1719_ net216 lf_inst.integrator\[19\] VGND VGND VPWR VPWR _0191_ sky130_fd_sc_hd__or2_1
XFILLER_58_289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_56_468 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_26_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_25_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_25_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_41_20 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_49_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_47_413 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_32_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_30_313 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1504_ _0494_ _0861_ _0903_ VGND VGND VPWR VPWR _0905_ sky130_fd_sc_hd__and3_1
X_1435_ _0794_ _0799_ _0800_ _0835_ VGND VGND VPWR VPWR _0836_ sky130_fd_sc_hd__o31ai_1
X_1366_ net310 net129 VGND VGND VPWR VPWR _0767_ sky130_fd_sc_hd__nor2_1
XFILLER_55_259 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_53_449 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1297_ net304 net32 net303 _0696_ VGND VGND VPWR VPWR _0698_ sky130_fd_sc_hd__or4_2
XFILLER_46_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_46_204 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_52_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xinput28 div_val[5] VGND VGND VPWR VPWR net28 sky130_fd_sc_hd__dlymetal6s2s_1
Xinput39 initial_freq[15] VGND VGND VPWR VPWR net39 sky130_fd_sc_hd__clkbuf_1
XFILLER_6_333 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xinput17 div_val[24] VGND VGND VPWR VPWR net17 sky130_fd_sc_hd__buf_1
X_1220_ dco_inst.accumulator\[22\] net81 VGND VGND VPWR VPWR _0631_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_9_182 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1151_ _0567_ _0570_ _0571_ VGND VGND VPWR VPWR _0016_ sky130_fd_sc_hd__a21oi_1
XFILLER_45_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_37_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1082_ _0509_ _0510_ _0511_ VGND VGND VPWR VPWR _0513_ sky130_fd_sc_hd__and3_1
XFILLER_60_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1984_ _0403_ _0415_ VGND VGND VPWR VPWR _0417_ sky130_fd_sc_hd__or2_4
XPHY_EDGE_ROW_21_Left_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1349_ net145 _0724_ VGND VGND VPWR VPWR _0750_ sky130_fd_sc_hd__nand2_1
X_1418_ net9 _0763_ VGND VGND VPWR VPWR _0819_ sky130_fd_sc_hd__xnor2_1
XFILLER_51_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_43_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_7_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xfanout150 net151 VGND VGND VPWR VPWR net150 sky130_fd_sc_hd__buf_1
Xfanout183 net184 VGND VGND VPWR VPWR net183 sky130_fd_sc_hd__buf_1
Xfanout172 net177 VGND VGND VPWR VPWR net172 sky130_fd_sc_hd__buf_1
Xfanout161 net163 VGND VGND VPWR VPWR net161 sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_47_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout194 net195 VGND VGND VPWR VPWR net194 sky130_fd_sc_hd__clkbuf_1
XFILLER_19_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_6_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_10_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1203_ net294 _0615_ _0616_ VGND VGND VPWR VPWR _0023_ sky130_fd_sc_hd__and3_1
X_2183_ clknet_4_7_0_sys_clk _0082_ VGND VGND VPWR VPWR lf_inst.error_in\[0\] sky130_fd_sc_hd__dfxtp_1
X_2252_ net235 _0151_ VGND VGND VPWR VPWR div_inst.counter\[31\] sky130_fd_sc_hd__dfxtp_1
XFILLER_26_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1134_ _0553_ _0556_ VGND VGND VPWR VPWR _0557_ sky130_fd_sc_hd__nand2_1
X_1065_ net336 _0491_ _0498_ _0501_ VGND VGND VPWR VPWR _0000_ sky130_fd_sc_hd__a31o_1
XFILLER_18_270 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1967_ net167 _0171_ _0177_ _0392_ VGND VGND VPWR VPWR _0402_ sky130_fd_sc_hd__o22a_1
X_1898_ net199 _0342_ VGND VGND VPWR VPWR _0343_ sky130_fd_sc_hd__or2_1
XFILLER_56_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_59_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_58_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_47_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold6 pfd_inst.state\[1\] VGND VGND VPWR VPWR net316 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_15_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_17_235 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1821_ net223 _0280_ VGND VGND VPWR VPWR _0281_ sky130_fd_sc_hd__or2_1
X_1752_ _0213_ _0215_ _0212_ VGND VGND VPWR VPWR _0220_ sky130_fd_sc_hd__a21o_1
X_1683_ net210 lf_inst.integrator\[15\] VGND VGND VPWR VPWR _0159_ sky130_fd_sc_hd__xnor2_4
X_2166_ clknet_4_9_0_sys_clk _0066_ VGND VGND VPWR VPWR lf_inst.integrator\[16\] sky130_fd_sc_hd__dfxtp_1
X_2235_ net235 _0134_ VGND VGND VPWR VPWR div_inst.counter\[14\] sky130_fd_sc_hd__dfxtp_1
X_2097_ net289 net115 net103 _0994_ VGND VGND VPWR VPWR _0151_ sky130_fd_sc_hd__and4_1
XTAP_TAPCELL_ROW_0_125 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1117_ dco_inst.accumulator\[8\] net97 VGND VGND VPWR VPWR _0542_ sky130_fd_sc_hd__nand2_1
Xclkbuf_4_9_0_sys_clk clknet_0_sys_clk VGND VGND VPWR VPWR clknet_4_9_0_sys_clk sky130_fd_sc_hd__clkbuf_8
XPHY_EDGE_ROW_3_Right_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_28_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_14_216 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_60_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_60_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_22_260 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_5_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2020_ _0239_ _0240_ net156 VGND VGND VPWR VPWR _0448_ sky130_fd_sc_hd__and3_1
XFILLER_39_118 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_35_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1735_ net344 net181 _0204_ net203 _0205_ VGND VGND VPWR VPWR _0070_ sky130_fd_sc_hd__a221o_1
X_1804_ net320 net188 _0265_ net206 _0266_ VGND VGND VPWR VPWR _0078_ sky130_fd_sc_hd__a221o_1
X_1666_ net211 net228 net247 VGND VGND VPWR VPWR _1041_ sky130_fd_sc_hd__mux2_4
X_1597_ net44 net328 net293 VGND VGND VPWR VPWR _0037_ sky130_fd_sc_hd__mux2_1
X_2218_ clknet_4_15_0_sys_clk _0117_ VGND VGND VPWR VPWR net88 sky130_fd_sc_hd__dfxtp_1
XFILLER_26_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2149_ clknet_4_3_0_sys_clk _0052_ VGND VGND VPWR VPWR unlock_timer\[2\] sky130_fd_sc_hd__dfxtp_1
XFILLER_44_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_29_151 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_17_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_17_324 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1520_ net280 net131 _0919_ VGND VGND VPWR VPWR _0921_ sky130_fd_sc_hd__or3b_1
X_1451_ div_inst.counter\[9\] div_inst.counter\[8\] VGND VGND VPWR VPWR _0852_ sky130_fd_sc_hd__and2_1
X_1382_ div_inst.counter\[31\] _0774_ VGND VGND VPWR VPWR _0783_ sky130_fd_sc_hd__or2_1
X_2003_ _0428_ _0430_ _0427_ VGND VGND VPWR VPWR _0433_ sky130_fd_sc_hd__a21o_1
XFILLER_35_198 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_35_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_23_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1718_ net216 lf_inst.integrator\[19\] VGND VGND VPWR VPWR _0190_ sky130_fd_sc_hd__nand2_1
X_1649_ net250 net34 VGND VGND VPWR VPWR _1027_ sky130_fd_sc_hd__and2_1
XTAP_TAPCELL_ROW_56_469 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_41_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_14_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_49_202 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_2_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_49_268 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_47_414 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_17_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_17_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_9_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_13_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_56_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1503_ _0861_ _0903_ VGND VGND VPWR VPWR _0904_ sky130_fd_sc_hd__nand2_1
X_1296_ net304 _0696_ VGND VGND VPWR VPWR _0697_ sky130_fd_sc_hd__nor2_1
X_1365_ net14 net13 net11 _0764_ VGND VGND VPWR VPWR _0766_ sky130_fd_sc_hd__or4_1
X_1434_ _0790_ _0791_ _0788_ VGND VGND VPWR VPWR _0835_ sky130_fd_sc_hd__a21oi_1
XFILLER_23_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_11_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_11_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_11_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xfanout310 net15 VGND VGND VPWR VPWR net310 sky130_fd_sc_hd__buf_1
XFILLER_52_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_6_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_14_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xinput18 div_val[25] VGND VGND VPWR VPWR net18 sky130_fd_sc_hd__buf_1
Xinput29 div_val[6] VGND VGND VPWR VPWR net29 sky130_fd_sc_hd__buf_1
XFILLER_6_345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_28_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_9_183 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1150_ _0567_ _0570_ net291 VGND VGND VPWR VPWR _0571_ sky130_fd_sc_hd__o21ai_1
XFILLER_52_219 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1081_ _0509_ _0510_ _0511_ VGND VGND VPWR VPWR _0512_ sky130_fd_sc_hd__a21o_1
X_1983_ _0195_ net155 _0402_ _0415_ _0400_ VGND VGND VPWR VPWR _0416_ sky130_fd_sc_hd__o221a_4
XFILLER_20_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1417_ _0764_ _0817_ VGND VGND VPWR VPWR _0818_ sky130_fd_sc_hd__and2_1
X_1279_ _0672_ _0678_ _0681_ net272 VGND VGND VPWR VPWR _0683_ sky130_fd_sc_hd__a31o_1
X_1348_ _0727_ _0748_ VGND VGND VPWR VPWR _0749_ sky130_fd_sc_hd__or2_1
XFILLER_28_227 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_36_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_11_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_3_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout151 net152 VGND VGND VPWR VPWR net151 sky130_fd_sc_hd__buf_1
Xfanout195 net197 VGND VGND VPWR VPWR net195 sky130_fd_sc_hd__clkbuf_1
Xfanout184 net189 VGND VGND VPWR VPWR net184 sky130_fd_sc_hd__buf_1
XTAP_TAPCELL_ROW_6_164 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout162 net163 VGND VGND VPWR VPWR net162 sky130_fd_sc_hd__buf_1
Xfanout173 net176 VGND VGND VPWR VPWR net173 sky130_fd_sc_hd__dlymetal6s2s_1
Xfanout140 div_inst.counter\[18\] VGND VGND VPWR VPWR net140 sky130_fd_sc_hd__buf_1
XFILLER_47_86 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_19_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_6_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_8_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2251_ net235 _0150_ VGND VGND VPWR VPWR div_inst.counter\[30\] sky130_fd_sc_hd__dfxtp_1
XFILLER_6_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1202_ _0606_ _0611_ _0612_ _0613_ VGND VGND VPWR VPWR _0616_ sky130_fd_sc_hd__a211o_1
X_2182_ clknet_4_12_0_sys_clk net296 VGND VGND VPWR VPWR lf_inst.sample_en sky130_fd_sc_hd__dfxtp_1
X_1064_ pfd_inst.fb_sync\[1\] _0493_ pfd_inst.state\[2\] _0500_ net258 VGND VGND VPWR
+ VPWR _0501_ sky130_fd_sc_hd__a311o_1
X_1133_ _0542_ _0544_ _0548_ _0546_ VGND VGND VPWR VPWR _0556_ sky130_fd_sc_hd__a31o_1
X_1966_ _0187_ net155 VGND VGND VPWR VPWR _0401_ sky130_fd_sc_hd__xnor2_1
XFILLER_18_282 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1897_ _0338_ _0341_ VGND VGND VPWR VPWR _0342_ sky130_fd_sc_hd__nor2_2
XFILLER_56_333 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_17_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_17_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_49_Left_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_3_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_3_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xhold7 lf_inst.integrator\[9\] VGND VGND VPWR VPWR net317 sky130_fd_sc_hd__dlygate4sd3_1
X_1820_ lf_inst.integrator\[31\] _0279_ VGND VGND VPWR VPWR _0280_ sky130_fd_sc_hd__xnor2_1
XTAP_TAPCELL_ROW_25_280 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1751_ net218 lf_inst.integrator\[23\] VGND VGND VPWR VPWR _0219_ sky130_fd_sc_hd__xor2_1
X_1682_ net210 lf_inst.integrator\[15\] VGND VGND VPWR VPWR _0158_ sky130_fd_sc_hd__nand2_1
X_2234_ net241 _0133_ VGND VGND VPWR VPWR div_inst.counter\[13\] sky130_fd_sc_hd__dfxtp_1
X_2165_ clknet_4_2_0_sys_clk _0065_ VGND VGND VPWR VPWR lf_inst.integrator\[15\] sky130_fd_sc_hd__dfxtp_1
X_2096_ net258 _0871_ net103 net115 VGND VGND VPWR VPWR _0150_ sky130_fd_sc_hd__and4bb_1
XFILLER_0_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_0_126 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1116_ dco_inst.accumulator\[8\] net97 VGND VGND VPWR VPWR _0541_ sky130_fd_sc_hd__or2_1
X_1949_ net166 _0161_ _0375_ _0376_ VGND VGND VPWR VPWR _0386_ sky130_fd_sc_hd__a211o_1
XFILLER_0_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_14_217 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_60_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_5_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_12_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_12_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_12_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_22_261 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_47_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_47_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_35_303 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_13_Right_13 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1803_ net272 net53 VGND VGND VPWR VPWR _0266_ sky130_fd_sc_hd__and2_1
XPHY_EDGE_ROW_22_Right_22 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1734_ net264 net45 VGND VGND VPWR VPWR _0205_ sky130_fd_sc_hd__and2_1
XFILLER_7_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1665_ lf_inst.integrator\[12\] net174 _1039_ net201 _1040_ VGND VGND VPWR VPWR _0062_
+ sky130_fd_sc_hd__a221o_1
X_1596_ net115 net103 _0996_ net258 VGND VGND VPWR VPWR _0036_ sky130_fd_sc_hd__a31oi_1
X_2217_ clknet_4_15_0_sys_clk _0116_ VGND VGND VPWR VPWR net87 sky130_fd_sc_hd__dfxtp_1
XPHY_EDGE_ROW_31_Right_31 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_38_174 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2079_ net269 _0924_ net107 net119 VGND VGND VPWR VPWR _0133_ sky130_fd_sc_hd__and4bb_1
X_2148_ clknet_4_0_0_sys_clk _0051_ VGND VGND VPWR VPWR unlock_timer\[1\] sky130_fd_sc_hd__dfxtp_1
XPHY_EDGE_ROW_40_Right_40 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_5_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_14_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_29_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_32_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1450_ net144 div_inst.counter\[8\] net134 VGND VGND VPWR VPWR _0851_ sky130_fd_sc_hd__and3_1
X_1381_ _0777_ _0778_ _0780_ _0781_ VGND VGND VPWR VPWR _0782_ sky130_fd_sc_hd__or4_1
X_2002_ _0221_ net160 VGND VGND VPWR VPWR _0432_ sky130_fd_sc_hd__xnor2_1
XFILLER_50_114 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_35_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_35_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1717_ net318 net178 _0188_ _0189_ VGND VGND VPWR VPWR _0068_ sky130_fd_sc_hd__a211o_1
X_1579_ _0915_ _0917_ _0979_ _0913_ VGND VGND VPWR VPWR _0980_ sky130_fd_sc_hd__and4b_1
XFILLER_6_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1648_ net191 _1025_ VGND VGND VPWR VPWR _1026_ sky130_fd_sc_hd__nor2_1
XFILLER_58_236 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_41_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_41_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_49_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_47_415 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_17_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_17_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_20_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1502_ net140 net130 net138 div_inst.counter\[19\] VGND VGND VPWR VPWR _0903_ sky130_fd_sc_hd__a31o_1
X_1433_ _0786_ net125 _0833_ VGND VGND VPWR VPWR _0834_ sky130_fd_sc_hd__and3_1
X_1295_ net28 net305 net29 net249 VGND VGND VPWR VPWR _0696_ sky130_fd_sc_hd__or4_2
X_1364_ net11 _0764_ VGND VGND VPWR VPWR _0765_ sky130_fd_sc_hd__nor2_1
XFILLER_23_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_23_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_11_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xfanout300 net301 VGND VGND VPWR VPWR net300 sky130_fd_sc_hd__buf_1
Xfanout311 net12 VGND VGND VPWR VPWR net311 sky130_fd_sc_hd__buf_1
XFILLER_54_283 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_52_440 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput19 div_val[26] VGND VGND VPWR VPWR net19 sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_6_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_9_184 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1080_ dco_inst.accumulator\[0\] net234 _0504_ _0505_ VGND VGND VPWR VPWR _0511_
+ sky130_fd_sc_hd__a31o_1
XFILLER_60_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_60_231 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1982_ _0401_ _0406_ _0407_ VGND VGND VPWR VPWR _0415_ sky130_fd_sc_hd__or3_4
XFILLER_20_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_20_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_9_140 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1347_ _0742_ _0747_ _0729_ VGND VGND VPWR VPWR _0748_ sky130_fd_sc_hd__a21oi_1
X_1416_ net9 net280 _0702_ net10 VGND VGND VPWR VPWR _0817_ sky130_fd_sc_hd__o31ai_1
X_1278_ _0672_ _0678_ _0681_ VGND VGND VPWR VPWR _0682_ sky130_fd_sc_hd__a21oi_1
XFILLER_28_239 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_28_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_11_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_3_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_305 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout152 div_inst.counter\[0\] VGND VGND VPWR VPWR net152 sky130_fd_sc_hd__clkbuf_1
Xfanout196 net197 VGND VGND VPWR VPWR net196 sky130_fd_sc_hd__dlymetal6s2s_1
Xfanout185 net188 VGND VGND VPWR VPWR net185 sky130_fd_sc_hd__dlymetal6s2s_1
Xfanout141 div_inst.counter\[13\] VGND VGND VPWR VPWR net141 sky130_fd_sc_hd__buf_1
Xfanout130 _0858_ VGND VGND VPWR VPWR net130 sky130_fd_sc_hd__buf_1
Xfanout174 net175 VGND VGND VPWR VPWR net174 sky130_fd_sc_hd__dlymetal6s2s_1
XTAP_TAPCELL_ROW_6_165 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout163 net165 VGND VGND VPWR VPWR net163 sky130_fd_sc_hd__clkbuf_1
XFILLER_42_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_34_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_6_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_10_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1201_ _0612_ _0613_ _0606_ _0611_ VGND VGND VPWR VPWR _0615_ sky130_fd_sc_hd__o211ai_1
X_2250_ net235 _0149_ VGND VGND VPWR VPWR div_inst.counter\[29\] sky130_fd_sc_hd__dfxtp_1
X_2181_ clknet_4_15_0_sys_clk _0081_ VGND VGND VPWR VPWR lf_inst.integrator\[31\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_33_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1063_ pfd_inst.state\[0\] _0497_ _0499_ VGND VGND VPWR VPWR _0500_ sky130_fd_sc_hd__and3_1
XFILLER_25_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1132_ _0543_ _0546_ _0547_ VGND VGND VPWR VPWR _0555_ sky130_fd_sc_hd__or3_1
XFILLER_18_294 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1965_ _0399_ VGND VGND VPWR VPWR _0400_ sky130_fd_sc_hd__inv_2
X_1896_ _0339_ _0340_ VGND VGND VPWR VPWR _0341_ sky130_fd_sc_hd__or2_1
XFILLER_56_345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_56_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_3_146 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_16_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold8 lf_inst.integrator\[18\] VGND VGND VPWR VPWR net318 sky130_fd_sc_hd__dlygate4sd3_1
X_1750_ net322 net182 _0217_ net203 _0218_ VGND VGND VPWR VPWR _0072_ sky130_fd_sc_hd__a221o_1
XTAP_TAPCELL_ROW_25_281 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xmax_cap127 _0465_ VGND VGND VPWR VPWR net127 sky130_fd_sc_hd__clkbuf_1
X_1681_ lf_inst.integrator\[14\] net172 _0156_ net202 _0157_ VGND VGND VPWR VPWR _0064_
+ sky130_fd_sc_hd__a221o_1
XFILLER_38_323 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_38_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2233_ net241 _0132_ VGND VGND VPWR VPWR div_inst.counter\[12\] sky130_fd_sc_hd__dfxtp_1
X_2164_ clknet_4_2_0_sys_clk _0064_ VGND VGND VPWR VPWR lf_inst.integrator\[14\] sky130_fd_sc_hd__dfxtp_1
XFILLER_53_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_38_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1115_ _0539_ _0540_ VGND VGND VPWR VPWR _0011_ sky130_fd_sc_hd__and2_1
XFILLER_0_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_0_127 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2095_ net258 _0877_ net103 net115 VGND VGND VPWR VPWR _0149_ sky130_fd_sc_hd__and4bb_1
X_1948_ _0384_ VGND VGND VPWR VPWR _0385_ sky130_fd_sc_hd__inv_2
X_1879_ net251 net60 net359 net173 _0326_ VGND VGND VPWR VPWR _0093_ sky130_fd_sc_hd__a221o_1
XFILLER_9_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_21_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_56_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_56_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_39_362 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_60_98 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_60_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_5_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_22_262 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_35_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_35_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_4_11_0_sys_clk clknet_0_sys_clk VGND VGND VPWR VPWR clknet_4_11_0_sys_clk
+ sky130_fd_sc_hd__clkbuf_8
XTAP_TAPCELL_ROW_45_398 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1802_ _0264_ VGND VGND VPWR VPWR _0265_ sky130_fd_sc_hd__inv_2
X_1733_ _0203_ VGND VGND VPWR VPWR _0204_ sky130_fd_sc_hd__inv_2
XFILLER_7_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1664_ net253 net36 VGND VGND VPWR VPWR _1040_ sky130_fd_sc_hd__and2_1
X_1595_ _0872_ _0992_ _0994_ _0995_ VGND VGND VPWR VPWR _0996_ sky130_fd_sc_hd__a211o_1
X_2216_ clknet_4_14_0_sys_clk _0115_ VGND VGND VPWR VPWR net86 sky130_fd_sc_hd__dfxtp_1
XFILLER_38_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_38_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_38_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2147_ clknet_4_3_0_sys_clk _0050_ VGND VGND VPWR VPWR unlock_timer\[0\] sky130_fd_sc_hd__dfxtp_1
XFILLER_53_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2078_ net269 _0928_ net107 net119 VGND VGND VPWR VPWR _0132_ sky130_fd_sc_hd__and4bb_1
XFILLER_14_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_39_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_39_22 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_55_32 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_55_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_55_10 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_17_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1380_ div_inst.counter\[28\] _0779_ VGND VGND VPWR VPWR _0781_ sky130_fd_sc_hd__nor2_1
X_2001_ net351 net182 _0431_ net203 _0218_ VGND VGND VPWR VPWR _0110_ sky130_fd_sc_hd__a221o_1
XFILLER_23_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1716_ net263 net42 VGND VGND VPWR VPWR _0189_ sky130_fd_sc_hd__and2_1
XFILLER_58_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_58_204 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1578_ net9 _0914_ VGND VGND VPWR VPWR _0979_ sky130_fd_sc_hd__or2_1
X_1647_ _1011_ _1024_ VGND VGND VPWR VPWR _1025_ sky130_fd_sc_hd__xor2_1
XFILLER_26_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_26_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_41_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_22_340 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_38_Left_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_57_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_57_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_49_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_49_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_55_460 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_17_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1363_ net10 net9 net280 _0702_ VGND VGND VPWR VPWR _0764_ sky130_fd_sc_hd__or4_1
X_1501_ net140 net130 net138 VGND VGND VPWR VPWR _0902_ sky130_fd_sc_hd__and3_1
X_1432_ _0816_ _0832_ _0831_ VGND VGND VPWR VPWR _0833_ sky130_fd_sc_hd__a21o_1
X_1294_ net305 net249 VGND VGND VPWR VPWR _0695_ sky130_fd_sc_hd__nor2_1
XFILLER_23_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_11_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_11_26 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout301 net66 VGND VGND VPWR VPWR net301 sky130_fd_sc_hd__buf_1
Xfanout312 net1 VGND VGND VPWR VPWR net312 sky130_fd_sc_hd__buf_1
XTAP_TAPCELL_ROW_52_441 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_10_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_10_354 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_22_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_9_185 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_60_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_60_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_60_210 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1981_ _0412_ _0413_ VGND VGND VPWR VPWR _0414_ sky130_fd_sc_hd__nand2_1
XFILLER_9_152 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1346_ _0743_ _0745_ _0746_ _0733_ net147 VGND VGND VPWR VPWR _0747_ sky130_fd_sc_hd__a32o_1
X_1415_ _0810_ _0812_ _0815_ VGND VGND VPWR VPWR _0816_ sky130_fd_sc_hd__nor3_1
X_1277_ _0679_ _0680_ VGND VGND VPWR VPWR _0681_ sky130_fd_sc_hd__nand2b_1
XFILLER_22_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xfanout120 net123 VGND VGND VPWR VPWR net120 sky130_fd_sc_hd__buf_1
Xfanout131 _0858_ VGND VGND VPWR VPWR net131 sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_3_317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout186 net187 VGND VGND VPWR VPWR net186 sky130_fd_sc_hd__clkbuf_1
XFILLER_47_33 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xfanout153 net154 VGND VGND VPWR VPWR net153 sky130_fd_sc_hd__clkbuf_1
Xfanout142 div_inst.counter\[12\] VGND VGND VPWR VPWR net142 sky130_fd_sc_hd__buf_1
Xfanout197 net198 VGND VGND VPWR VPWR net197 sky130_fd_sc_hd__buf_1
Xfanout175 net176 VGND VGND VPWR VPWR net175 sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_6_166 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout164 net165 VGND VGND VPWR VPWR net164 sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_42_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2180_ clknet_4_13_0_sys_clk _0080_ VGND VGND VPWR VPWR lf_inst.integrator\[30\]
+ sky130_fd_sc_hd__dfxtp_1
X_1200_ dco_inst.accumulator\[19\] net77 VGND VGND VPWR VPWR _0614_ sky130_fd_sc_hd__nand2_1
XFILLER_2_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1062_ net288 _0498_ _0499_ VGND VGND VPWR VPWR _0001_ sky130_fd_sc_hd__and3_1
XPHY_EDGE_ROW_25_Left_86 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1131_ _0546_ net97 dco_inst.accumulator\[8\] VGND VGND VPWR VPWR _0554_ sky130_fd_sc_hd__nand3b_1
XFILLER_18_240 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1964_ _0187_ net155 VGND VGND VPWR VPWR _0399_ sky130_fd_sc_hd__nor2_1
X_1895_ lf_inst.integrator\[8\] net161 VGND VGND VPWR VPWR _0340_ sky130_fd_sc_hd__and2_1
XFILLER_0_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_56_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1329_ net312 net311 net23 net26 VGND VGND VPWR VPWR _0730_ sky130_fd_sc_hd__o31ai_1
XTAP_TAPCELL_ROW_3_147 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_33_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold9 lf_inst.integrator\[19\] VGND VGND VPWR VPWR net319 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_25_282 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_15_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1680_ net252 net38 VGND VGND VPWR VPWR _0157_ sky130_fd_sc_hd__and2_1
Xmax_cap128 _0365_ VGND VGND VPWR VPWR net128 sky130_fd_sc_hd__clkbuf_1
X_2232_ net242 _0131_ VGND VGND VPWR VPWR div_inst.counter\[11\] sky130_fd_sc_hd__dfxtp_1
X_2163_ clknet_4_6_0_sys_clk _0063_ VGND VGND VPWR VPWR lf_inst.integrator\[13\] sky130_fd_sc_hd__dfxtp_1
X_1114_ _0537_ _0538_ net287 VGND VGND VPWR VPWR _0540_ sky130_fd_sc_hd__o21a_1
XFILLER_0_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_0_128 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2094_ net258 _0874_ net102 net114 VGND VGND VPWR VPWR _0148_ sky130_fd_sc_hd__and4bb_1
X_1947_ net170 _0171_ VGND VGND VPWR VPWR _0384_ sky130_fd_sc_hd__xnor2_1
X_1878_ _0324_ _0325_ VGND VGND VPWR VPWR _0326_ sky130_fd_sc_hd__nor2_1
XFILLER_56_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_44_316 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_44_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_39_363 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_29_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_28_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_22_263 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_5_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_45_399 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_43_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1732_ _0200_ _0202_ VGND VGND VPWR VPWR _0203_ sky130_fd_sc_hd__xnor2_2
X_1801_ _0258_ _0262_ VGND VGND VPWR VPWR _0264_ sky130_fd_sc_hd__xnor2_1
XFILLER_7_261 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1663_ _1036_ _1038_ VGND VGND VPWR VPWR _1039_ sky130_fd_sc_hd__xnor2_2
Xclkbuf_4_15_0_sys_clk clknet_0_sys_clk VGND VGND VPWR VPWR clknet_4_15_0_sys_clk
+ sky130_fd_sc_hd__clkbuf_8
XPHY_EDGE_ROW_7_Right_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1594_ net25 _0871_ VGND VGND VPWR VPWR _0995_ sky130_fd_sc_hd__nor2_1
X_2215_ clknet_4_14_0_sys_clk _0114_ VGND VGND VPWR VPWR net85 sky130_fd_sc_hd__dfxtp_1
XFILLER_53_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2077_ net269 _0933_ net107 net119 VGND VGND VPWR VPWR _0131_ sky130_fd_sc_hd__and4bb_1
XTAP_TAPCELL_ROW_36_344 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2146_ clknet_4_3_0_sys_clk _0049_ VGND VGND VPWR VPWR dynamic_kp\[2\] sky130_fd_sc_hd__dfxtp_1
XPHY_EDGE_ROW_12_Left_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_39_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_29_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_55_44 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_44_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_17_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_40_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_4_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_20_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_58_480 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2000_ _0429_ _0430_ VGND VGND VPWR VPWR _0431_ sky130_fd_sc_hd__xnor2_1
XFILLER_50_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_50_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_31_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_16_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1715_ net193 _0187_ VGND VGND VPWR VPWR _0188_ sky130_fd_sc_hd__nor2_1
X_1646_ _1022_ _1023_ VGND VGND VPWR VPWR _1024_ sky130_fd_sc_hd__nand2b_1
X_1577_ _0931_ _0940_ _0977_ VGND VGND VPWR VPWR _0978_ sky130_fd_sc_hd__and3_1
X_2129_ clknet_4_15_0_sys_clk _0032_ VGND VGND VPWR VPWR dco_inst.accumulator\[28\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_25_36 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_57_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_49_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_2_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_17_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_17_135 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_55_461 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_32_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_15_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1500_ _0897_ _0890_ _0893_ _0900_ VGND VGND VPWR VPWR _0901_ sky130_fd_sc_hd__and4b_1
Xoutput90 net90 VGND VGND VPWR VPWR debug_dco_word[30] sky130_fd_sc_hd__buf_2
X_1293_ net312 net311 net26 net23 VGND VGND VPWR VPWR _0694_ sky130_fd_sc_hd__or4_1
X_1362_ net280 _0702_ VGND VGND VPWR VPWR _0763_ sky130_fd_sc_hd__nor2_1
X_1431_ _0821_ _0826_ _0823_ VGND VGND VPWR VPWR _0832_ sky130_fd_sc_hd__o21ai_1
XFILLER_48_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout302 net5 VGND VGND VPWR VPWR net302 sky130_fd_sc_hd__buf_1
X_1629_ net298 net313 VGND VGND VPWR VPWR _0057_ sky130_fd_sc_hd__and2_1
XFILLER_11_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_54_263 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_52_442 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_52_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_9_186 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_60_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1980_ _0203_ net153 VGND VGND VPWR VPWR _0413_ sky130_fd_sc_hd__nand2_1
XFILLER_9_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xrebuffer1 _1020_ VGND VGND VPWR VPWR net170 sky130_fd_sc_hd__dlygate4sd1_1
X_1276_ dco_inst.accumulator\[29\] net88 VGND VGND VPWR VPWR _0680_ sky130_fd_sc_hd__nand2_1
X_1345_ net148 _0740_ _0741_ _0744_ VGND VGND VPWR VPWR _0746_ sky130_fd_sc_hd__a211o_1
X_1414_ div_inst.counter\[20\] _0811_ _0814_ div_inst.counter\[19\] _0809_ VGND VGND
+ VPWR VPWR _0815_ sky130_fd_sc_hd__a221o_1
XFILLER_36_263 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_36_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout110 net111 VGND VGND VPWR VPWR net110 sky130_fd_sc_hd__clkbuf_1
Xfanout154 net155 VGND VGND VPWR VPWR net154 sky130_fd_sc_hd__buf_1
Xfanout121 net123 VGND VGND VPWR VPWR net121 sky130_fd_sc_hd__clkbuf_1
Xfanout143 div_inst.counter\[12\] VGND VGND VPWR VPWR net143 sky130_fd_sc_hd__clkbuf_1
Xfanout132 _0855_ VGND VGND VPWR VPWR net132 sky130_fd_sc_hd__buf_1
Xfanout165 _0303_ VGND VGND VPWR VPWR net165 sky130_fd_sc_hd__buf_1
XFILLER_3_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_6_167 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_47_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout187 net188 VGND VGND VPWR VPWR net187 sky130_fd_sc_hd__dlymetal6s2s_1
Xfanout198 net199 VGND VGND VPWR VPWR net198 sky130_fd_sc_hd__clkbuf_2
Xfanout176 net177 VGND VGND VPWR VPWR net176 sky130_fd_sc_hd__buf_1
XFILLER_27_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_42_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_6_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_10_174 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_0_Left_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1130_ _0551_ _0552_ VGND VGND VPWR VPWR _0553_ sky130_fd_sc_hd__nand2_1
XFILLER_19_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1061_ pfd_inst.ref_sync\[1\] _0491_ VGND VGND VPWR VPWR _0499_ sky130_fd_sc_hd__nand2_1
X_1963_ net248 net232 net213 VGND VGND VPWR VPWR _0398_ sky130_fd_sc_hd__a21bo_1
X_1894_ lf_inst.integrator\[8\] net161 VGND VGND VPWR VPWR _0339_ sky130_fd_sc_hd__nor2_1
X_1259_ _0665_ _0664_ VGND VGND VPWR VPWR _0030_ sky130_fd_sc_hd__and2b_1
X_1328_ div_inst.counter\[6\] _0726_ _0728_ div_inst.counter\[5\] VGND VGND VPWR VPWR
+ _0729_ sky130_fd_sc_hd__a22o_1
XTAP_TAPCELL_ROW_3_148 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_24_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_24_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_59_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_59_152 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_30_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_25_283 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2231_ net241 _0130_ VGND VGND VPWR VPWR div_inst.counter\[10\] sky130_fd_sc_hd__dfxtp_1
XFILLER_2_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1113_ _0537_ _0538_ VGND VGND VPWR VPWR _0539_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_0_129 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2093_ net257 _0881_ net102 net114 VGND VGND VPWR VPWR _0147_ sky130_fd_sc_hd__and4bb_1
XFILLER_17_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2162_ clknet_4_6_0_sys_clk _0062_ VGND VGND VPWR VPWR lf_inst.integrator\[12\] sky130_fd_sc_hd__dfxtp_1
XFILLER_21_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_21_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1946_ net333 net172 _0163_ _0383_ VGND VGND VPWR VPWR _0103_ sky130_fd_sc_hd__a211o_1
X_1877_ _0317_ _0321_ _0323_ net191 VGND VGND VPWR VPWR _0325_ sky130_fd_sc_hd__a31o_1
XFILLER_0_118 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_56_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_44_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_44_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_39_364 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_22_264 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_47_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_47_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1800_ _0259_ _0261_ _0258_ VGND VGND VPWR VPWR _0263_ sky130_fd_sc_hd__a21bo_1
XFILLER_18_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1731_ _0182_ _0183_ _0192_ _0201_ VGND VGND VPWR VPWR _0202_ sky130_fd_sc_hd__o31ai_4
XFILLER_7_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1662_ _1029_ _1037_ VGND VGND VPWR VPWR _1038_ sky130_fd_sc_hd__nor2_1
X_2214_ clknet_4_14_0_sys_clk _0113_ VGND VGND VPWR VPWR net84 sky130_fd_sc_hd__dfxtp_1
X_1593_ div_inst.counter\[31\] _0870_ _0993_ VGND VGND VPWR VPWR _0994_ sky130_fd_sc_hd__a21o_1
XFILLER_53_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2076_ net270 _0935_ net107 net119 VGND VGND VPWR VPWR _0130_ sky130_fd_sc_hd__and4bb_1
XTAP_TAPCELL_ROW_36_345 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_0_sys_clk sys_clk VGND VGND VPWR VPWR clknet_0_sys_clk sky130_fd_sc_hd__clkbuf_16
XFILLER_26_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2145_ clknet_4_0_0_sys_clk _0048_ VGND VGND VPWR VPWR lf_inst.integrator\[0\] sky130_fd_sc_hd__dfxtp_1
X_1929_ net375 net174 _0367_ _0369_ _1040_ VGND VGND VPWR VPWR _0100_ sky130_fd_sc_hd__a221o_1
XFILLER_39_13 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_30_59 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_29_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_25_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_4_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_58_481 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_35_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_33_326 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1576_ _0939_ _0943_ _0937_ VGND VGND VPWR VPWR _0977_ sky130_fd_sc_hd__a21o_1
X_1714_ _0185_ _0186_ VGND VGND VPWR VPWR _0187_ sky130_fd_sc_hd__nand2_1
XFILLER_6_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1645_ lf_inst.integrator\[10\] net168 VGND VGND VPWR VPWR _1023_ sky130_fd_sc_hd__or2_1
X_2128_ clknet_4_14_0_sys_clk _0031_ VGND VGND VPWR VPWR dco_inst.accumulator\[27\]
+ sky130_fd_sc_hd__dfxtp_1
X_2059_ _0466_ _0480_ _0473_ _0479_ VGND VGND VPWR VPWR _0482_ sky130_fd_sc_hd__a31oi_4
XFILLER_41_128 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_41_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_14_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_41_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_1_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_17_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_17_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_55_462 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_9_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_15_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1430_ _0803_ _0810_ _0830_ VGND VGND VPWR VPWR _0831_ sky130_fd_sc_hd__a21o_1
Xoutput91 net91 VGND VGND VPWR VPWR debug_dco_word[31] sky130_fd_sc_hd__buf_2
XFILLER_55_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xoutput80 net80 VGND VGND VPWR VPWR debug_dco_word[21] sky130_fd_sc_hd__buf_2
X_1292_ net312 net311 VGND VGND VPWR VPWR _0693_ sky130_fd_sc_hd__nor2_1
X_1361_ _0706_ _0707_ _0711_ _0761_ VGND VGND VPWR VPWR _0762_ sky130_fd_sc_hd__a22o_1
X_1559_ div_inst.counter\[3\] _0847_ VGND VGND VPWR VPWR _0960_ sky130_fd_sc_hd__nor2_1
Xfanout303 net31 VGND VGND VPWR VPWR net303 sky130_fd_sc_hd__buf_1
X_1628_ net289 net65 VGND VGND VPWR VPWR _0056_ sky130_fd_sc_hd__and2_1
XFILLER_54_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_54_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_36_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_54_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_52_443 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_52_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_14_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_22_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_37_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_9_187 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xrebuffer2 lf_inst.error_in\[1\] VGND VGND VPWR VPWR net227 sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_13_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_20_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_47_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1413_ _0765_ _0813_ VGND VGND VPWR VPWR _0814_ sky130_fd_sc_hd__and2b_1
X_1275_ dco_inst.accumulator\[29\] net88 VGND VGND VPWR VPWR _0679_ sky130_fd_sc_hd__nor2_1
X_1344_ net148 _0740_ _0744_ VGND VGND VPWR VPWR _0745_ sky130_fd_sc_hd__or3_1
XFILLER_3_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_51_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_36_275 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout122 net123 VGND VGND VPWR VPWR net122 sky130_fd_sc_hd__clkbuf_1
Xfanout144 div_inst.counter\[7\] VGND VGND VPWR VPWR net144 sky130_fd_sc_hd__buf_1
Xfanout188 net189 VGND VGND VPWR VPWR net188 sky130_fd_sc_hd__buf_1
Xfanout155 net159 VGND VGND VPWR VPWR net155 sky130_fd_sc_hd__dlymetal6s2s_1
Xfanout199 _1015_ VGND VGND VPWR VPWR net199 sky130_fd_sc_hd__buf_1
Xfanout111 net112 VGND VGND VPWR VPWR net111 sky130_fd_sc_hd__buf_1
Xfanout166 _1021_ VGND VGND VPWR VPWR net166 sky130_fd_sc_hd__dlymetal6s2s_1
Xfanout177 net190 VGND VGND VPWR VPWR net177 sky130_fd_sc_hd__dlymetal6s2s_1
XTAP_TAPCELL_ROW_6_168 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_29_Right_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_38_Right_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_6_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_8_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_12_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_47_Right_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1060_ pfd_inst.fb_sync\[1\] _0493_ pfd_inst.state\[0\] pfd_inst.state\[1\] VGND
+ VGND VPWR VPWR _0498_ sky130_fd_sc_hd__a31o_1
XPHY_EDGE_ROW_56_Right_56 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1962_ net247 net232 net213 VGND VGND VPWR VPWR _0397_ sky130_fd_sc_hd__a21boi_1
XFILLER_33_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1893_ _0321_ _0336_ _0337_ VGND VGND VPWR VPWR _0338_ sky130_fd_sc_hd__o21ba_1
X_1258_ _0660_ _0662_ _0663_ net266 VGND VGND VPWR VPWR _0665_ sky130_fd_sc_hd__a31o_1
X_1327_ net28 _0695_ VGND VGND VPWR VPWR _0728_ sky130_fd_sc_hd__xnor2_1
X_1189_ dco_inst.accumulator\[18\] net76 VGND VGND VPWR VPWR _0604_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_3_149 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_3_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_58_45 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_15_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_15_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_15_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_23_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2230_ net241 _0129_ VGND VGND VPWR VPWR div_inst.counter\[9\] sky130_fd_sc_hd__dfxtp_1
XFILLER_31_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1112_ _0525_ _0530_ _0532_ _0529_ VGND VGND VPWR VPWR _0538_ sky130_fd_sc_hd__a31o_1
XFILLER_0_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2092_ net256 _0880_ net102 net114 VGND VGND VPWR VPWR _0146_ sky130_fd_sc_hd__and4bb_1
X_2161_ clknet_4_6_0_sys_clk _0061_ VGND VGND VPWR VPWR lf_inst.integrator\[11\] sky130_fd_sc_hd__dfxtp_1
XFILLER_9_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_21_204 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_21_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1945_ _0381_ _0382_ VGND VGND VPWR VPWR _0383_ sky130_fd_sc_hd__nor2_1
X_1876_ _0317_ _0321_ _0323_ VGND VGND VPWR VPWR _0324_ sky130_fd_sc_hd__a21oi_1
XFILLER_29_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_28_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_39_365 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_60_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_12_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_22_265 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_47_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_47_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_13_210 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1730_ _0181_ _0184_ _0190_ VGND VGND VPWR VPWR _0201_ sky130_fd_sc_hd__and3_1
X_1592_ div_inst.counter\[31\] div_inst.counter\[30\] _0868_ VGND VGND VPWR VPWR _0993_
+ sky130_fd_sc_hd__and3b_1
XFILLER_11_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1661_ _1011_ _1023_ _1030_ _1022_ VGND VGND VPWR VPWR _1037_ sky130_fd_sc_hd__a211oi_2
X_2213_ clknet_4_11_0_sys_clk _0112_ VGND VGND VPWR VPWR net83 sky130_fd_sc_hd__dfxtp_1
XFILLER_38_112 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2144_ clknet_4_6_0_sys_clk _0047_ VGND VGND VPWR VPWR pfd_inst.fb_sync\[2\] sky130_fd_sc_hd__dfxtp_1
XPHY_EDGE_ROW_46_Left_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2075_ net271 _0938_ net107 net119 VGND VGND VPWR VPWR _0129_ sky130_fd_sc_hd__and4bb_1
XTAP_TAPCELL_ROW_36_346 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_14_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_30_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1859_ net250 net55 net338 net171 VGND VGND VPWR VPWR _0310_ sky130_fd_sc_hd__a22oi_1
X_1928_ net192 _0368_ VGND VGND VPWR VPWR _0369_ sky130_fd_sc_hd__nor2_1
XPHY_EDGE_ROW_55_Left_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_44_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_29_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_52_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_40_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_29_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_4_277 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_50_118 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_33_327 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_31_310 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_29_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1713_ _0182_ _0183_ _0184_ VGND VGND VPWR VPWR _0186_ sky130_fd_sc_hd__nand3_1
X_1575_ _0929_ _0930_ _0921_ _0927_ VGND VGND VPWR VPWR _0976_ sky130_fd_sc_hd__a2bb2o_1
X_1644_ lf_inst.integrator\[10\] net168 VGND VGND VPWR VPWR _1022_ sky130_fd_sc_hd__and2_1
X_2127_ clknet_4_14_0_sys_clk _0030_ VGND VGND VPWR VPWR dco_inst.accumulator\[26\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_26_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2058_ _0466_ _0473_ _0479_ _0480_ VGND VGND VPWR VPWR _0481_ sky130_fd_sc_hd__and4_1
XFILLER_41_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_1_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_55_463 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_30_308 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_9_314 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1360_ _0755_ _0758_ _0714_ VGND VGND VPWR VPWR _0761_ sky130_fd_sc_hd__a21o_1
Xoutput70 net70 VGND VGND VPWR VPWR debug_dco_word[12] sky130_fd_sc_hd__buf_2
X_1291_ _0691_ _0692_ VGND VGND VPWR VPWR _0035_ sky130_fd_sc_hd__nor2_1
Xoutput81 net81 VGND VGND VPWR VPWR debug_dco_word[22] sky130_fd_sc_hd__buf_2
Xoutput92 net92 VGND VGND VPWR VPWR debug_dco_word[3] sky130_fd_sc_hd__buf_2
XFILLER_23_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1558_ _0950_ _0955_ _0958_ _0952_ VGND VGND VPWR VPWR _0959_ sky130_fd_sc_hd__and4bb_1
Xfanout304 net30 VGND VGND VPWR VPWR net304 sky130_fd_sc_hd__buf_1
X_1489_ net17 _0889_ VGND VGND VPWR VPWR _0890_ sky130_fd_sc_hd__or2_1
X_1627_ net209 _1009_ VGND VGND VPWR VPWR _0055_ sky130_fd_sc_hd__and2_1
XTAP_TAPCELL_ROW_52_444 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_60_202 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_45_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_9_122 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1343_ _0731_ _0735_ _0737_ _0738_ VGND VGND VPWR VPWR _0744_ sky130_fd_sc_hd__or4_1
X_1412_ net11 _0764_ VGND VGND VPWR VPWR _0813_ sky130_fd_sc_hd__nand2_1
XFILLER_5_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1274_ net299 _0677_ _0678_ VGND VGND VPWR VPWR _0032_ sky130_fd_sc_hd__and3_1
XFILLER_36_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_51_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_22_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_59_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout145 div_inst.counter\[7\] VGND VGND VPWR VPWR net145 sky130_fd_sc_hd__buf_1
Xfanout134 _0850_ VGND VGND VPWR VPWR net134 sky130_fd_sc_hd__buf_1
Xfanout156 net158 VGND VGND VPWR VPWR net156 sky130_fd_sc_hd__dlymetal6s2s_1
Xfanout189 net190 VGND VGND VPWR VPWR net189 sky130_fd_sc_hd__buf_1
Xfanout123 net124 VGND VGND VPWR VPWR net123 sky130_fd_sc_hd__buf_1
Xfanout167 _1021_ VGND VGND VPWR VPWR net167 sky130_fd_sc_hd__clkbuf_1
Xfanout178 net180 VGND VGND VPWR VPWR net178 sky130_fd_sc_hd__buf_1
Xfanout112 _0846_ VGND VGND VPWR VPWR net112 sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_6_169 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout101 net102 VGND VGND VPWR VPWR net101 sky130_fd_sc_hd__buf_1
XFILLER_8_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_10_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_18_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_53_90 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1961_ net332 net178 _0179_ _0396_ VGND VGND VPWR VPWR _0105_ sky130_fd_sc_hd__a211o_1
X_1892_ lf_inst.integrator\[4\] lf_inst.integrator\[5\] lf_inst.integrator\[6\] lf_inst.integrator\[7\]
+ net161 VGND VGND VPWR VPWR _0337_ sky130_fd_sc_hd__o41a_1
X_1326_ net145 _0724_ _0726_ div_inst.counter\[6\] VGND VGND VPWR VPWR _0727_ sky130_fd_sc_hd__o22ai_1
X_1257_ _0662_ _0663_ _0660_ VGND VGND VPWR VPWR _0664_ sky130_fd_sc_hd__a21o_1
X_1188_ _0602_ _0603_ VGND VGND VPWR VPWR _0021_ sky130_fd_sc_hd__nor2_1
XFILLER_24_202 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_58_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_47_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2160_ clknet_4_1_0_sys_clk _0060_ VGND VGND VPWR VPWR lf_inst.integrator\[10\] sky130_fd_sc_hd__dfxtp_1
XFILLER_46_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1111_ _0535_ _0536_ VGND VGND VPWR VPWR _0537_ sky130_fd_sc_hd__and2_1
XFILLER_0_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2091_ net256 _0884_ net102 net114 VGND VGND VPWR VPWR _0145_ sky130_fd_sc_hd__and4bb_1
X_1875_ lf_inst.integrator\[5\] net161 VGND VGND VPWR VPWR _0323_ sky130_fd_sc_hd__xnor2_1
XFILLER_9_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_21_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_21_249 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1944_ _0374_ _0378_ _0380_ net192 VGND VGND VPWR VPWR _0382_ sky130_fd_sc_hd__a31o_1
XTAP_TAPCELL_ROW_39_366 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1309_ div_inst.counter\[14\] _0705_ _0709_ net141 VGND VGND VPWR VPWR _0710_ sky130_fd_sc_hd__a22o_1
XFILLER_29_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_28_16 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_35_319 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_7_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_13_211 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1591_ _0875_ _0878_ _0990_ _0991_ VGND VGND VPWR VPWR _0992_ sky130_fd_sc_hd__o22ai_1
X_1660_ lf_inst.integrator\[12\] net169 VGND VGND VPWR VPWR _1036_ sky130_fd_sc_hd__xnor2_4
X_2212_ clknet_4_11_0_sys_clk _0111_ VGND VGND VPWR VPWR net82 sky130_fd_sc_hd__dfxtp_1
XFILLER_38_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_38_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2143_ clknet_4_7_0_sys_clk _0046_ VGND VGND VPWR VPWR pfd_inst.fb_sync\[1\] sky130_fd_sc_hd__dfxtp_1
XFILLER_22_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_53_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2074_ net270 _0942_ net108 net120 VGND VGND VPWR VPWR _0128_ sky130_fd_sc_hd__and4bb_1
XTAP_TAPCELL_ROW_36_347 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_14_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_19_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1858_ _0306_ _0307_ net191 VGND VGND VPWR VPWR _0309_ sky130_fd_sc_hd__a21o_1
X_1927_ _0363_ _0366_ VGND VGND VPWR VPWR _0368_ sky130_fd_sc_hd__and2_1
X_1789_ _0247_ _0248_ _0245_ VGND VGND VPWR VPWR _0253_ sky130_fd_sc_hd__o21ai_1
XFILLER_25_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_40_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_4_289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_45_91 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_35_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_33_328 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_1 net267 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_1712_ _0183_ _0184_ _0182_ VGND VGND VPWR VPWR _0185_ sky130_fd_sc_hd__a21o_1
XFILLER_31_355 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1643_ net248 net210 VGND VGND VPWR VPWR _1021_ sky130_fd_sc_hd__nand2b_1
XFILLER_6_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1574_ _0931_ _0944_ _0946_ _0974_ VGND VGND VPWR VPWR _0975_ sky130_fd_sc_hd__and4_1
X_2126_ clknet_4_14_0_sys_clk _0029_ VGND VGND VPWR VPWR dco_inst.accumulator\[25\]
+ sky130_fd_sc_hd__dfxtp_1
X_2057_ net127 _0464_ _0468_ _0474_ VGND VGND VPWR VPWR _0480_ sky130_fd_sc_hd__a211o_1
XPHY_EDGE_ROW_16_Left_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_41_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_49_208 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_1_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_13_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_17_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_40_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_30_309 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_9_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xoutput82 net82 VGND VGND VPWR VPWR debug_dco_word[23] sky130_fd_sc_hd__buf_2
Xoutput93 net93 VGND VGND VPWR VPWR debug_dco_word[4] sky130_fd_sc_hd__buf_2
Xoutput71 net71 VGND VGND VPWR VPWR debug_dco_word[13] sky130_fd_sc_hd__buf_2
X_1290_ _0684_ _0689_ _0690_ net272 VGND VGND VPWR VPWR _0692_ sky130_fd_sc_hd__a31o_1
XFILLER_48_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1626_ unlock_timer\[1\] unlock_timer\[0\] _1008_ unlock_timer\[5\] VGND VGND VPWR
+ VPWR _1009_ sky130_fd_sc_hd__a31o_1
X_1557_ net303 _0948_ _0949_ net304 _0957_ VGND VGND VPWR VPWR _0958_ sky130_fd_sc_hd__o221a_1
Xfanout305 net27 VGND VGND VPWR VPWR net305 sky130_fd_sc_hd__buf_1
X_1488_ div_inst.counter\[23\] _0863_ VGND VGND VPWR VPWR _0889_ sky130_fd_sc_hd__xnor2_1
XFILLER_54_288 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_52_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2109_ clknet_4_5_0_sys_clk _0012_ VGND VGND VPWR VPWR dco_inst.accumulator\[8\]
+ sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_52_445 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_6_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_22_174 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_45_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_45_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_60_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_26_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_9_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_13_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_9_178 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1273_ _0662_ _0674_ _0676_ _0673_ VGND VGND VPWR VPWR _0678_ sky130_fd_sc_hd__a211o_1
X_1342_ _0735_ _0737_ _0731_ VGND VGND VPWR VPWR _0743_ sky130_fd_sc_hd__o21bai_1
X_1411_ net139 _0807_ _0811_ div_inst.counter\[20\] VGND VGND VPWR VPWR _0812_ sky130_fd_sc_hd__o22ai_1
XFILLER_51_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_51_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1609_ net288 net341 VGND VGND VPWR VPWR _0047_ sky130_fd_sc_hd__and2_1
Xfanout113 net114 VGND VGND VPWR VPWR net113 sky130_fd_sc_hd__buf_1
Xfanout102 net106 VGND VGND VPWR VPWR net102 sky130_fd_sc_hd__buf_1
Xfanout146 div_inst.counter\[4\] VGND VGND VPWR VPWR net146 sky130_fd_sc_hd__buf_1
Xfanout157 net158 VGND VGND VPWR VPWR net157 sky130_fd_sc_hd__buf_1
XFILLER_47_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xfanout135 _0700_ VGND VGND VPWR VPWR net135 sky130_fd_sc_hd__buf_1
Xfanout179 net180 VGND VGND VPWR VPWR net179 sky130_fd_sc_hd__clkbuf_1
Xfanout124 _0841_ VGND VGND VPWR VPWR net124 sky130_fd_sc_hd__clkbuf_1
XFILLER_27_211 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout168 _1020_ VGND VGND VPWR VPWR net168 sky130_fd_sc_hd__buf_1
Xclkbuf_4_0_0_sys_clk clknet_0_sys_clk VGND VGND VPWR VPWR clknet_4_0_0_sys_clk sky130_fd_sc_hd__clkbuf_8
XPHY_EDGE_ROW_19_Left_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_6_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_2_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_37_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_33_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_18_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1960_ net193 _0395_ VGND VGND VPWR VPWR _0396_ sky130_fd_sc_hd__nor2_1
X_1891_ _0323_ _0327_ _0333_ VGND VGND VPWR VPWR _0336_ sky130_fd_sc_hd__or3b_1
XFILLER_52_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_11_194 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1256_ _0645_ _0654_ _0653_ VGND VGND VPWR VPWR _0663_ sky130_fd_sc_hd__a21bo_1
X_1325_ _0696_ _0725_ VGND VGND VPWR VPWR _0726_ sky130_fd_sc_hd__and2_1
X_1187_ _0591_ _0598_ _0601_ net263 VGND VGND VPWR VPWR _0603_ sky130_fd_sc_hd__a31o_1
XFILLER_58_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_55_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_2_140 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_15_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_30_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_4_Left_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_48_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_38_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1110_ dco_inst.accumulator\[7\] net96 VGND VGND VPWR VPWR _0536_ sky130_fd_sc_hd__or2_1
X_2090_ net257 _0885_ net101 net113 VGND VGND VPWR VPWR _0144_ sky130_fd_sc_hd__and4bb_1
XFILLER_0_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1874_ net202 _0320_ _0321_ _0322_ VGND VGND VPWR VPWR _0092_ sky130_fd_sc_hd__a31o_1
X_1943_ _0374_ _0378_ _0380_ VGND VGND VPWR VPWR _0381_ sky130_fd_sc_hd__a21oi_1
X_1239_ _0631_ _0639_ _0647_ _0636_ _0641_ VGND VGND VPWR VPWR _0648_ sky130_fd_sc_hd__o221a_1
XFILLER_44_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_39_367 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1308_ _0701_ _0708_ VGND VGND VPWR VPWR _0709_ sky130_fd_sc_hd__nor2_1
XFILLER_60_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_44_38 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_44_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_47_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_18_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_11_261 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_11_294 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1590_ net24 _0877_ _0875_ VGND VGND VPWR VPWR _0991_ sky130_fd_sc_hd__a21bo_1
XFILLER_53_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_53_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2211_ clknet_4_10_0_sys_clk _0110_ VGND VGND VPWR VPWR net81 sky130_fd_sc_hd__dfxtp_1
X_2073_ net274 _0948_ net109 net121 VGND VGND VPWR VPWR _0127_ sky130_fd_sc_hd__and4bb_1
XFILLER_26_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_15_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2142_ clknet_4_7_0_sys_clk _0045_ VGND VGND VPWR VPWR pfd_inst.fb_sync\[0\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_44_392 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_348 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1788_ net221 lf_inst.integrator\[27\] VGND VGND VPWR VPWR _0252_ sky130_fd_sc_hd__xnor2_2
XFILLER_30_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1857_ _0306_ _0307_ VGND VGND VPWR VPWR _0308_ sky130_fd_sc_hd__nor2_1
X_1926_ _0363_ _0366_ VGND VGND VPWR VPWR _0367_ sky130_fd_sc_hd__or2_1
XFILLER_29_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold60 lf_inst.integrator\[4\] VGND VGND VPWR VPWR net370 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_33_329 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1711_ lf_inst.integrator\[16\] lf_inst.integrator\[17\] net212 VGND VGND VPWR VPWR
+ _0184_ sky130_fd_sc_hd__o21ai_1
X_1642_ net247 net211 VGND VGND VPWR VPWR _1020_ sky130_fd_sc_hd__and2b_1
X_1573_ _0969_ _0973_ _0972_ VGND VGND VPWR VPWR _0974_ sky130_fd_sc_hd__or3b_1
X_2125_ clknet_4_11_0_sys_clk _0028_ VGND VGND VPWR VPWR dco_inst.accumulator\[24\]
+ sky130_fd_sc_hd__dfxtp_1
X_2056_ _0477_ _0478_ VGND VGND VPWR VPWR _0479_ sky130_fd_sc_hd__or2_4
XFILLER_34_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_41_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1909_ _1025_ net137 VGND VGND VPWR VPWR _0352_ sky130_fd_sc_hd__and2_1
XFILLER_22_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_1_249 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_40_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_40_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_9_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xoutput83 net83 VGND VGND VPWR VPWR debug_dco_word[24] sky130_fd_sc_hd__buf_2
XPHY_EDGE_ROW_33_Left_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xoutput72 net72 VGND VGND VPWR VPWR debug_dco_word[14] sky130_fd_sc_hd__buf_2
Xoutput94 net94 VGND VGND VPWR VPWR debug_dco_word[5] sky130_fd_sc_hd__buf_2
XFILLER_0_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_16_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1556_ net29 _0849_ _0953_ VGND VGND VPWR VPWR _0957_ sky130_fd_sc_hd__or3_1
XFILLER_8_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1625_ unlock_timer\[4\] unlock_timer\[3\] unlock_timer\[2\] VGND VGND VPWR VPWR
+ _1008_ sky130_fd_sc_hd__and3_1
Xfanout306 net27 VGND VGND VPWR VPWR net306 sky130_fd_sc_hd__clkbuf_1
XFILLER_39_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1487_ net18 _0885_ VGND VGND VPWR VPWR _0888_ sky130_fd_sc_hd__nor2_1
XFILLER_52_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2039_ _0436_ _0438_ _0463_ _0459_ VGND VGND VPWR VPWR _0464_ sky130_fd_sc_hd__a211o_1
X_2108_ clknet_4_5_0_sys_clk _0011_ VGND VGND VPWR VPWR dco_inst.accumulator\[7\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_22_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_60_490 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_45_245 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_9_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_13_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1410_ net13 _0765_ VGND VGND VPWR VPWR _0811_ sky130_fd_sc_hd__xnor2_1
X_1272_ _0675_ _0676_ _0673_ VGND VGND VPWR VPWR _0677_ sky130_fd_sc_hd__o21ai_1
X_1341_ div_inst.counter\[5\] _0728_ _0733_ net147 VGND VGND VPWR VPWR _0742_ sky130_fd_sc_hd__o22a_1
XFILLER_3_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_51_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_59_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout147 div_inst.counter\[4\] VGND VGND VPWR VPWR net147 sky130_fd_sc_hd__clkbuf_1
X_1539_ net4 _0933_ VGND VGND VPWR VPWR _0940_ sky130_fd_sc_hd__or2_1
Xfanout103 net105 VGND VGND VPWR VPWR net103 sky130_fd_sc_hd__buf_1
X_1608_ net288 net314 VGND VGND VPWR VPWR _0046_ sky130_fd_sc_hd__and2_1
Xfanout136 _0304_ VGND VGND VPWR VPWR net136 sky130_fd_sc_hd__buf_1
Xfanout114 net118 VGND VGND VPWR VPWR net114 sky130_fd_sc_hd__buf_1
Xfanout158 net159 VGND VGND VPWR VPWR net158 sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_27_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout169 _1020_ VGND VGND VPWR VPWR net169 sky130_fd_sc_hd__buf_6
XFILLER_12_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_4_4_0_sys_clk clknet_0_sys_clk VGND VGND VPWR VPWR clknet_4_4_0_sys_clk sky130_fd_sc_hd__clkbuf_8
XTAP_TAPCELL_ROW_5_160 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_2_333 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_33_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_16_Right_16 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_41_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_25_Right_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1890_ net352 net176 _0335_ net200 _0998_ VGND VGND VPWR VPWR _0095_ sky130_fd_sc_hd__a221o_1
XFILLER_45_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_11_195 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1255_ _0648_ _0649_ _0661_ VGND VGND VPWR VPWR _0662_ sky130_fd_sc_hd__a21o_1
XFILLER_56_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1324_ net28 net305 net249 net29 VGND VGND VPWR VPWR _0725_ sky130_fd_sc_hd__o31ai_1
XPHY_EDGE_ROW_34_Right_34 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1186_ _0591_ _0598_ _0601_ VGND VGND VPWR VPWR _0602_ sky130_fd_sc_hd__a21oi_1
XFILLER_32_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_24_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_20_Left_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_43_Right_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_3_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_59_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_59_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_58_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_52_Right_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_2_141 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_15_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_23_95 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_23_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_38_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1942_ net166 _0161_ VGND VGND VPWR VPWR _0380_ sky130_fd_sc_hd__xnor2_1
X_1873_ net251 net59 net93 net171 VGND VGND VPWR VPWR _0322_ sky130_fd_sc_hd__a22o_1
XFILLER_29_307 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_28_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1238_ _0632_ _0639_ _0640_ VGND VGND VPWR VPWR _0647_ sky130_fd_sc_hd__or3_1
X_1307_ net302 net135 VGND VGND VPWR VPWR _0708_ sky130_fd_sc_hd__and2_1
X_1169_ dco_inst.accumulator\[15\] net73 VGND VGND VPWR VPWR _0587_ sky130_fd_sc_hd__and2_1
XFILLER_60_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_11_240 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_11_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2210_ clknet_4_10_0_sys_clk _0109_ VGND VGND VPWR VPWR net80 sky130_fd_sc_hd__dfxtp_1
X_2072_ net274 _0949_ net109 net121 VGND VGND VPWR VPWR _0126_ sky130_fd_sc_hd__and4bb_1
XTAP_TAPCELL_ROW_36_349 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2141_ clknet_4_4_0_sys_clk _0044_ VGND VGND VPWR VPWR lf_inst.integrator\[8\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_44_393 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1925_ _0364_ _0365_ VGND VGND VPWR VPWR _0366_ sky130_fd_sc_hd__nand2_1
X_1787_ net346 net187 _0250_ _0251_ VGND VGND VPWR VPWR _0076_ sky130_fd_sc_hd__a211o_1
X_1856_ net231 _0495_ _1010_ VGND VGND VPWR VPWR _0307_ sky130_fd_sc_hd__or3b_2
XPHY_EDGE_ROW_2_Right_2 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_42_Left_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_4_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_20_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold61 net86 VGND VGND VPWR VPWR net371 sky130_fd_sc_hd__dlygate4sd3_1
Xhold50 net76 VGND VGND VPWR VPWR net360 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_29_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_51_Left_112 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_43_140 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_41_374 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_31_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_60_Left_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1572_ _0950_ _0956_ _0958_ _0955_ VGND VGND VPWR VPWR _0973_ sky130_fd_sc_hd__a22o_1
X_1710_ _0167_ _0166_ _0169_ _0175_ VGND VGND VPWR VPWR _0183_ sky130_fd_sc_hd__a211o_4
X_1641_ net317 net171 _1019_ _1016_ VGND VGND VPWR VPWR _0059_ sky130_fd_sc_hd__a211o_1
X_2124_ clknet_4_10_0_sys_clk _0027_ VGND VGND VPWR VPWR dco_inst.accumulator\[23\]
+ sky130_fd_sc_hd__dfxtp_1
X_2055_ net223 _0277_ VGND VGND VPWR VPWR _0478_ sky130_fd_sc_hd__nor2_1
X_1839_ lf_inst.zero_error_count\[2\] lf_inst.zero_error_count\[1\] lf_inst.zero_error_count\[0\]
+ VGND VGND VPWR VPWR _0294_ sky130_fd_sc_hd__and3_1
X_1908_ _1025_ net137 VGND VGND VPWR VPWR _0351_ sky130_fd_sc_hd__nor2_1
XFILLER_1_206 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_57_210 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_13_313 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_15_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xoutput84 net84 VGND VGND VPWR VPWR debug_dco_word[25] sky130_fd_sc_hd__buf_2
XFILLER_48_232 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput73 net73 VGND VGND VPWR VPWR debug_dco_word[15] sky130_fd_sc_hd__buf_2
Xoutput95 net95 VGND VGND VPWR VPWR debug_dco_word[6] sky130_fd_sc_hd__buf_2
XFILLER_31_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_31_176 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1555_ net303 _0948_ VGND VGND VPWR VPWR _0956_ sky130_fd_sc_hd__or2_1
X_1624_ net209 _1007_ VGND VGND VPWR VPWR _0054_ sky130_fd_sc_hd__and2_1
Xfanout307 net21 VGND VGND VPWR VPWR net307 sky130_fd_sc_hd__buf_1
XFILLER_36_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2107_ clknet_4_4_0_sys_clk _0010_ VGND VGND VPWR VPWR dco_inst.accumulator\[6\]
+ sky130_fd_sc_hd__dfxtp_1
X_1486_ _0886_ VGND VGND VPWR VPWR _0887_ sky130_fd_sc_hd__inv_2
X_2038_ _0441_ _0447_ _0448_ _0454_ VGND VGND VPWR VPWR _0463_ sky130_fd_sc_hd__or4_4
XTAP_TAPCELL_ROW_60_491 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_6_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_60_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_45_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_13_198 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1340_ net148 _0740_ net151 net1 VGND VGND VPWR VPWR _0741_ sky130_fd_sc_hd__a2bb2o_1
X_1271_ _0658_ _0668_ _0666_ VGND VGND VPWR VPWR _0676_ sky130_fd_sc_hd__a21o_1
XFILLER_3_77 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_8_180 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_51_249 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_59_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_59_305 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout148 div_inst.counter\[1\] VGND VGND VPWR VPWR net148 sky130_fd_sc_hd__buf_1
Xfanout159 _0398_ VGND VGND VPWR VPWR net159 sky130_fd_sc_hd__buf_1
X_1538_ net3 _0935_ _0938_ net308 VGND VGND VPWR VPWR _0939_ sky130_fd_sc_hd__o22a_1
Xfanout104 net105 VGND VGND VPWR VPWR net104 sky130_fd_sc_hd__clkbuf_1
Xfanout115 net117 VGND VGND VPWR VPWR net115 sky130_fd_sc_hd__buf_1
Xfanout137 _0304_ VGND VGND VPWR VPWR net137 sky130_fd_sc_hd__buf_1
X_1607_ net288 div_inst.clk_out VGND VGND VPWR VPWR _0045_ sky130_fd_sc_hd__and2_1
X_1469_ div_inst.counter\[30\] _0868_ VGND VGND VPWR VPWR _0870_ sky130_fd_sc_hd__nand2_1
XFILLER_47_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_27_268 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_10_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkbuf_4_8_0_sys_clk clknet_0_sys_clk VGND VGND VPWR VPWR clknet_4_8_0_sys_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_5_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_5_161 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_28_296 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_41_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_11_196 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1323_ _0697_ _0723_ VGND VGND VPWR VPWR _0724_ sky130_fd_sc_hd__nor2_1
XFILLER_5_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1254_ _0646_ _0653_ _0654_ VGND VGND VPWR VPWR _0661_ sky130_fd_sc_hd__nand3_1
XFILLER_49_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1185_ _0599_ _0600_ VGND VGND VPWR VPWR _0601_ sky130_fd_sc_hd__nand2_1
XFILLER_24_227 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_17_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_3_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_58_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_2_142 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_2_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_46_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1872_ _0313_ _0318_ _0319_ VGND VGND VPWR VPWR _0321_ sky130_fd_sc_hd__or3_4
XFILLER_9_32 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1941_ net354 net172 _0379_ net202 _0157_ VGND VGND VPWR VPWR _0102_ sky130_fd_sc_hd__a221o_1
X_1306_ div_inst.counter\[15\] _0704_ VGND VGND VPWR VPWR _0707_ sky130_fd_sc_hd__nand2_1
XFILLER_29_319 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1237_ _0644_ _0645_ VGND VGND VPWR VPWR _0646_ sky130_fd_sc_hd__and2_1
XFILLER_52_322 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_37_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1168_ dco_inst.accumulator\[15\] net73 VGND VGND VPWR VPWR _0586_ sky130_fd_sc_hd__nor2_1
X_1099_ _0520_ _0524_ _0525_ _0526_ VGND VGND VPWR VPWR _0527_ sky130_fd_sc_hd__o211ai_1
XFILLER_20_263 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_20_285 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_47_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_28_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_18_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_18_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_43_311 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_50_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_11_252 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2140_ clknet_4_5_0_sys_clk _0043_ VGND VGND VPWR VPWR lf_inst.integrator\[7\] sky130_fd_sc_hd__dfxtp_1
XFILLER_53_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2071_ net274 _0954_ net109 net121 VGND VGND VPWR VPWR _0125_ sky130_fd_sc_hd__and4bb_1
XFILLER_46_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_44_394 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1855_ lf_inst.integrator\[2\] net164 VGND VGND VPWR VPWR _0306_ sky130_fd_sc_hd__xnor2_1
X_1924_ _0340_ _0346_ _0351_ _0357_ VGND VGND VPWR VPWR _0365_ sky130_fd_sc_hd__nor4_1
X_1786_ net266 net51 VGND VGND VPWR VPWR _0251_ sky130_fd_sc_hd__and2_1
XFILLER_39_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_29_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_52_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_4_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xhold40 net90 VGND VGND VPWR VPWR net350 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_20_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_35_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xhold51 lf_inst.integrator\[17\] VGND VGND VPWR VPWR net361 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_29_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xhold62 net97 VGND VGND VPWR VPWR net372 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_41_375 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1571_ _0962_ _0965_ _0971_ _0959_ VGND VGND VPWR VPWR _0972_ sky130_fd_sc_hd__or4bb_1
XFILLER_3_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1640_ net250 net64 VGND VGND VPWR VPWR _1019_ sky130_fd_sc_hd__and2_1
X_2123_ clknet_4_10_0_sys_clk _0026_ VGND VGND VPWR VPWR dco_inst.accumulator\[22\]
+ sky130_fd_sc_hd__dfxtp_1
X_2054_ net223 _0277_ VGND VGND VPWR VPWR _0477_ sky130_fd_sc_hd__and2_4
XFILLER_34_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_34_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_32_320 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_22_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1838_ lf_inst.zero_error_count\[1\] net363 net296 _0293_ VGND VGND VPWR VPWR _0085_
+ sky130_fd_sc_hd__o211a_1
X_1907_ net98 net173 _0350_ net200 _1019_ VGND VGND VPWR VPWR _0097_ sky130_fd_sc_hd__a221o_1
X_1769_ net217 lf_inst.integrator\[25\] VGND VGND VPWR VPWR _0235_ sky130_fd_sc_hd__or2_1
XFILLER_1_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_57_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_40_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_13_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_15_31 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_31_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xoutput85 net85 VGND VGND VPWR VPWR debug_dco_word[26] sky130_fd_sc_hd__buf_2
XFILLER_48_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xoutput74 net74 VGND VGND VPWR VPWR debug_dco_word[16] sky130_fd_sc_hd__buf_2
XFILLER_0_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xoutput96 net96 VGND VGND VPWR VPWR debug_dco_word[7] sky130_fd_sc_hd__buf_2
XFILLER_16_174 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_31_188 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_31_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1554_ net28 _0951_ _0954_ net29 VGND VGND VPWR VPWR _0955_ sky130_fd_sc_hd__a22o_1
Xfanout308 net2 VGND VGND VPWR VPWR net308 sky130_fd_sc_hd__buf_1
X_1623_ unlock_timer\[4\] _1006_ VGND VGND VPWR VPWR _1007_ sky130_fd_sc_hd__xnor2_1
X_1485_ net19 _0884_ _0885_ net309 VGND VGND VPWR VPWR _0886_ sky130_fd_sc_hd__a22o_1
.ends
